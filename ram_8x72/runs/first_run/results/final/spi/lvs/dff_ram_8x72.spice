* NGSPICE file created from dff_ram_8x72.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

.subckt dff_ram_8x72 VGND VPWR address[0] address[1] address[2] clk rdata[0] rdata[10]
+ rdata[11] rdata[12] rdata[13] rdata[14] rdata[15] rdata[16] rdata[17] rdata[18]
+ rdata[19] rdata[1] rdata[20] rdata[21] rdata[22] rdata[23] rdata[24] rdata[25] rdata[26]
+ rdata[27] rdata[28] rdata[29] rdata[2] rdata[30] rdata[31] rdata[32] rdata[33] rdata[34]
+ rdata[35] rdata[36] rdata[37] rdata[38] rdata[39] rdata[3] rdata[40] rdata[41] rdata[42]
+ rdata[43] rdata[44] rdata[45] rdata[46] rdata[47] rdata[48] rdata[49] rdata[4] rdata[50]
+ rdata[51] rdata[52] rdata[53] rdata[54] rdata[55] rdata[56] rdata[57] rdata[58]
+ rdata[59] rdata[5] rdata[60] rdata[61] rdata[62] rdata[63] rdata[64] rdata[65] rdata[66]
+ rdata[67] rdata[68] rdata[69] rdata[6] rdata[70] rdata[71] rdata[7] rdata[8] rdata[9]
+ wdata[0] wdata[10] wdata[11] wdata[12] wdata[13] wdata[14] wdata[15] wdata[16] wdata[17]
+ wdata[18] wdata[19] wdata[1] wdata[20] wdata[21] wdata[22] wdata[23] wdata[24] wdata[25]
+ wdata[26] wdata[27] wdata[28] wdata[29] wdata[2] wdata[30] wdata[31] wdata[32] wdata[33]
+ wdata[34] wdata[35] wdata[36] wdata[37] wdata[38] wdata[39] wdata[3] wdata[40] wdata[41]
+ wdata[42] wdata[43] wdata[44] wdata[45] wdata[46] wdata[47] wdata[48] wdata[49]
+ wdata[4] wdata[50] wdata[51] wdata[52] wdata[53] wdata[54] wdata[55] wdata[56] wdata[57]
+ wdata[58] wdata[59] wdata[5] wdata[60] wdata[61] wdata[62] wdata[63] wdata[64] wdata[65]
+ wdata[66] wdata[67] wdata[68] wdata[69] wdata[6] wdata[70] wdata[71] wdata[7] wdata[8]
+ wdata[9] wr_n
X_3155_ _1495_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
X_2106_ _0753_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_1
X_3086_ _1077_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__buf_2
XFILLER_0_89_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3988_ _0954_ net786 _1947_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2939_ _1036_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_20_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4609_ clknet_leaf_15_clk _0445_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold351 instance_1.mem\[2\]\[45\] VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__dlygate4sd3_1
Xhold340 instance_0.mem\[3\]\[9\] VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__dlygate4sd3_1
Xhold362 instance_1.mem\[1\]\[12\] VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__dlygate4sd3_1
Xhold384 instance_0.mem\[3\]\[58\] VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__dlygate4sd3_1
Xhold395 instance_1.mem\[2\]\[56\] VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__dlygate4sd3_1
Xhold373 instance_0.mem\[1\]\[50\] VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3911_ _1908_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__clkbuf_1
X_3842_ net733 net23 _1867_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__mux2_1
X_3773_ net704 net68 _1830_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2724_ net349 _1171_ _1175_ _1176_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__o22a_1
X_2655_ net215 _1104_ _1122_ _1124_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__o22a_1
X_4325_ clknet_leaf_20_clk net182 VGND VGND VPWR VPWR instance_0.rdata\[47\] sky130_fd_sc_hd__dfxtp_1
X_2586_ net229 _1026_ _1065_ _1068_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__o22a_1
X_4256_ clknet_leaf_11_clk _0092_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3207_ _1523_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
X_4187_ clknet_leaf_10_clk _0023_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_3138_ _1484_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3069_ instance_1.mem\[1\]\[49\] _1418_ _1432_ instance_1.mem\[3\]\[49\] _1433_ VGND
+ VGND VPWR VPWR _1436_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_25_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold170 _0215_ VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
Xhold181 instance_0.rdata\[17\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
Xhold192 _0206_ VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2440_ net25 VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_11_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2371_ net73 VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4110_ net868 net59 _2011_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__mux2_1
X_4041_ _0845_ net906 _1976_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4874_ clknet_leaf_36_clk _0710_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3825_ net638 net14 _1860_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__mux2_1
X_3756_ net382 net60 _1823_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2707_ net373 _1149_ _1160_ _1163_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__o22a_1
X_3687_ net453 _0971_ _1780_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2638_ net600 _1110_ _1111_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__mux2_1
X_2569_ _0810_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__buf_2
X_4308_ clknet_leaf_28_clk _0144_ VGND VGND VPWR VPWR instance_0.rdata\[30\] sky130_fd_sc_hd__dfxtp_1
X_4239_ clknet_leaf_27_clk _0075_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[33\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_67_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_76_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_85_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3610_ net441 _0890_ _1743_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__mux2_1
X_4590_ clknet_leaf_24_clk _0426_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_3541_ net464 _0823_ _1700_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3472_ net727 _0915_ _1665_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__mux2_1
X_2423_ _0959_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
X_2354_ _0912_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2285_ _0863_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
X_4024_ _0828_ net803 _1969_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4857_ clknet_leaf_50_clk _0693_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3808_ _1852_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__clkbuf_1
X_4788_ clknet_leaf_48_clk _0624_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3739_ _1814_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_7_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2070_ instance_0.rdata\[10\] instance_1.rdata\[10\] _0729_ VGND VGND VPWR VPWR _0734_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2972_ _1297_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__buf_2
XFILLER_0_8_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4711_ clknet_leaf_49_clk _0547_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4642_ clknet_leaf_50_clk _0478_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4573_ clknet_leaf_51_clk _0409_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold703 instance_0.mem\[3\]\[17\] VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlygate4sd3_1
Xhold725 instance_0.mem\[1\]\[33\] VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__dlygate4sd3_1
X_3524_ net519 _0967_ _1693_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__mux2_1
Xhold736 instance_0.mem\[0\]\[71\] VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold714 instance_0.mem\[1\]\[26\] VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__dlygate4sd3_1
Xhold758 instance_1.mem\[0\]\[45\] VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__dlygate4sd3_1
X_3455_ _0896_ net957 _1656_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__mux2_1
Xhold769 instance_0.mem\[2\]\[2\] VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlygate4sd3_1
Xhold747 instance_1.mem\[0\]\[61\] VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__dlygate4sd3_1
X_2406_ _0908_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__buf_2
X_3386_ _0825_ net978 _1621_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2337_ _0899_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
X_2268_ _0812_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__buf_2
X_4007_ _1925_ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__buf_2
X_2199_ instance_0.rdata\[69\] instance_1.rdata\[69\] _0800_ VGND VGND VPWR VPWR _0804_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold41 instance_0.rdata\[7\] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 _0140_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 _0156_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 instance_0.rdata\[28\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 _0180_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold96 _0146_ VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 instance_1.rdata\[24\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_5 _1276_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3240_ _0838_ net881 _1541_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__mux2_1
X_3171_ _0932_ net946 _1498_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__mux2_1
X_2122_ instance_0.rdata\[34\] instance_1.rdata\[34\] _0757_ VGND VGND VPWR VPWR _0762_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2053_ instance_0.rdata\[2\] instance_1.rdata\[2\] _0722_ VGND VGND VPWR VPWR _0725_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2955_ net331 _1347_ _1348_ _1351_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__o22a_1
X_2886_ net265 _1294_ _1295_ _1299_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__o22a_1
X_4625_ clknet_leaf_1_clk _0461_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_4556_ clknet_leaf_0_clk _0392_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[62\] sky130_fd_sc_hd__dfxtp_1
Xhold500 instance_0.mem\[0\]\[60\] VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__dlygate4sd3_1
Xhold511 instance_0.mem\[0\]\[46\] VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold544 instance_1.mem\[2\]\[66\] VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold522 instance_1.mem\[1\]\[21\] VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__dlygate4sd3_1
X_3507_ net760 _0950_ _1686_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__mux2_1
Xhold533 instance_1.mem\[2\]\[48\] VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__dlygate4sd3_1
Xhold588 instance_1.mem\[1\]\[27\] VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlygate4sd3_1
X_4487_ clknet_leaf_58_clk _0323_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold566 instance_1.mem\[3\]\[7\] VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dlygate4sd3_1
Xhold577 instance_1.mem\[0\]\[2\] VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dlygate4sd3_1
Xhold555 instance_0.mem\[3\]\[46\] VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dlygate4sd3_1
X_3438_ _0877_ net658 _1649_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__mux2_1
Xhold599 instance_0.mem\[0\]\[16\] VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dlygate4sd3_1
X_3369_ _0971_ net801 _1606_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_43_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_226 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput97 net97 VGND VGND VPWR VPWR rdata[28] sky130_fd_sc_hd__clkbuf_4
Xoutput86 net86 VGND VGND VPWR VPWR rdata[18] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_85_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2740_ _1188_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_81_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2671_ net253 _1131_ _1134_ _1136_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__o22a_1
X_4410_ clknet_leaf_0_clk _0246_ VGND VGND VPWR VPWR instance_1.rdata\[60\] sky130_fd_sc_hd__dfxtp_1
X_4341_ clknet_leaf_57_clk net152 VGND VGND VPWR VPWR instance_0.rdata\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4272_ clknet_leaf_54_clk _0108_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_3223_ _0823_ net863 _1526_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__mux2_1
X_3154_ _0915_ net824 _1491_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__mux2_1
X_3085_ _1447_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
X_2105_ instance_0.rdata\[26\] instance_1.rdata\[26\] _0750_ VGND VGND VPWR VPWR _0753_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3987_ _1950_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2938_ instance_1.mem\[1\]\[16\] _1272_ _1311_ instance_1.mem\[3\]\[16\] VGND VGND
+ VPWR VPWR _1338_ sky130_fd_sc_hd__a22o_1
X_2869_ net3 VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__buf_1
X_4608_ clknet_leaf_15_clk _0444_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_4539_ clknet_leaf_14_clk _0375_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[45\] sky130_fd_sc_hd__dfxtp_1
Xhold341 instance_1.mem\[2\]\[42\] VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__dlygate4sd3_1
Xhold330 instance_1.rdata\[71\] VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__dlygate4sd3_1
Xhold352 instance_1.mem\[1\]\[24\] VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__dlygate4sd3_1
Xhold396 instance_0.mem\[0\]\[61\] VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__dlygate4sd3_1
Xhold385 instance_0.rdata\[61\] VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__dlygate4sd3_1
Xhold374 instance_1.mem\[1\]\[66\] VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__dlygate4sd3_1
Xhold363 instance_0.mem\[2\]\[56\] VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3910_ net532 net57 _1903_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3841_ _1870_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__clkbuf_1
X_3772_ _1832_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__clkbuf_1
X_2723_ instance_0.mem\[1\]\[35\] _1173_ _1135_ instance_0.mem\[2\]\[35\] _1151_ VGND
+ VGND VPWR VPWR _1176_ sky130_fd_sc_hd__a221o_1
XFILLER_0_54_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2654_ instance_0.mem\[1\]\[18\] _1106_ _1123_ instance_0.mem\[0\]\[18\] _1091_ VGND
+ VGND VPWR VPWR _1124_ sky130_fd_sc_hd__a221o_1
X_2585_ instance_0.mem\[0\]\[5\] _1067_ _1040_ instance_0.mem\[2\]\[5\] _1057_ VGND
+ VGND VPWR VPWR _1068_ sky130_fd_sc_hd__a221o_1
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4324_ clknet_leaf_20_clk net150 VGND VGND VPWR VPWR instance_0.rdata\[46\] sky130_fd_sc_hd__dfxtp_1
X_4255_ clknet_leaf_12_clk _0091_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_3206_ _0967_ net825 _1519_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4186_ clknet_leaf_12_clk _0022_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_3137_ net583 _1483_ _1287_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_53_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3068_ instance_1.mem\[0\]\[49\] _1371_ _1408_ instance_1.mem\[2\]\[49\] VGND VGND
+ VPWR VPWR _1435_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_25_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold160 _0229_ VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold171 instance_0.rdata\[67\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold193 instance_0.rdata\[29\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 _0131_ VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_28_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2370_ _0923_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4040_ _1979_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4873_ clknet_leaf_33_clk _0709_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3824_ _1861_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__clkbuf_1
X_3755_ _1794_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__buf_2
XFILLER_0_54_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3686_ _1785_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2706_ instance_0.mem\[1\]\[31\] _1140_ _1123_ instance_0.mem\[0\]\[31\] _1162_ VGND
+ VGND VPWR VPWR _1163_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2637_ _1023_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__buf_4
XFILLER_0_10_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2568_ instance_0.mem\[0\]\[2\] _1053_ _1048_ instance_0.mem\[3\]\[2\] VGND VGND
+ VPWR VPWR _1054_ sky130_fd_sc_hd__a22o_1
X_4307_ clknet_leaf_29_clk net342 VGND VGND VPWR VPWR instance_0.rdata\[29\] sky130_fd_sc_hd__dfxtp_1
X_2499_ _0867_ net677 _1002_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__mux2_1
X_4238_ clknet_leaf_24_clk _0074_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4169_ clknet_leaf_25_clk _0005_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3540_ _1705_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3471_ _1668_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__clkbuf_1
X_2422_ _0958_ net894 _0948_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__mux2_1
X_2353_ _0911_ net836 _0909_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__mux2_1
X_4023_ _1970_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__clkbuf_1
X_2284_ net653 _0862_ _0852_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4856_ clknet_leaf_53_clk _0692_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3807_ net552 net6 _1846_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__mux2_1
X_4787_ clknet_leaf_37_clk _0623_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3738_ net425 net51 _1809_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__mux2_1
X_3669_ _1776_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_58_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_58_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_72_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2971_ instance_1.mem\[1\]\[24\] _1362_ _1311_ instance_1.mem\[3\]\[24\] VGND VGND
+ VPWR VPWR _1363_ sky130_fd_sc_hd__a22o_1
X_4710_ clknet_leaf_56_clk _0546_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4641_ clknet_leaf_50_clk _0477_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4572_ clknet_leaf_48_clk _0408_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold726 instance_1.mem\[0\]\[35\] VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__dlygate4sd3_1
Xhold715 instance_0.mem\[1\]\[35\] VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__dlygate4sd3_1
X_3523_ _1696_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__clkbuf_1
Xhold737 instance_0.mem\[1\]\[0\] VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__dlygate4sd3_1
Xhold704 instance_1.mem\[0\]\[19\] VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlygate4sd3_1
X_3454_ _1658_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__clkbuf_1
Xhold748 instance_1.rdata\[14\] VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__dlygate4sd3_1
Xhold759 instance_0.mem\[1\]\[18\] VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__dlygate4sd3_1
X_2405_ net13 VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__dlymetal6s2s_1
X_3385_ _1620_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__buf_2
X_2336_ net571 _0898_ _0892_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_49_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_49_clk sky130_fd_sc_hd__clkbuf_8
X_2267_ net46 VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4006_ _1960_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2198_ _0803_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4839_ clknet_leaf_3_clk _0675_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold20 _0172_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 instance_0.rdata\[24\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 _0142_ VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 _0121_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 instance_1.rdata\[12\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold75 instance_1.rdata\[44\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 instance_1.rdata\[54\] VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 _0210_ VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_6 _1278_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3170_ _1503_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
X_2121_ _0761_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_1
X_2052_ _0724_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2954_ instance_1.mem\[1\]\[19\] _1349_ _1350_ instance_1.mem\[0\]\[19\] _1331_ VGND
+ VGND VPWR VPWR _1351_ sky130_fd_sc_hd__a221o_1
X_2885_ instance_1.mem\[1\]\[2\] _1260_ _1241_ instance_1.mem\[0\]\[2\] _1298_ VGND
+ VGND VPWR VPWR _1299_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4624_ clknet_leaf_4_clk _0460_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold501 instance_0.mem\[1\]\[6\] VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__dlygate4sd3_1
X_4555_ clknet_leaf_60_clk _0391_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[61\] sky130_fd_sc_hd__dfxtp_1
Xhold534 instance_1.mem\[0\]\[42\] VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__dlygate4sd3_1
Xhold523 instance_1.mem\[3\]\[26\] VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__dlygate4sd3_1
Xhold545 instance_1.mem\[2\]\[7\] VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__dlygate4sd3_1
X_3506_ _1687_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__clkbuf_1
Xhold512 instance_0.mem\[1\]\[21\] VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__dlygate4sd3_1
X_4486_ clknet_leaf_58_clk _0322_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[64\] sky130_fd_sc_hd__dfxtp_1
Xhold556 instance_1.mem\[2\]\[68\] VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__dlygate4sd3_1
Xhold578 instance_1.mem\[0\]\[54\] VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dlygate4sd3_1
Xhold567 instance_0.mem\[0\]\[54\] VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dlygate4sd3_1
Xhold589 instance_1.mem\[0\]\[11\] VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlygate4sd3_1
X_3437_ _1620_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__buf_2
X_3368_ _1611_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__clkbuf_1
X_2319_ net707 _0886_ _0878_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3299_ _1573_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_84_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput98 net98 VGND VGND VPWR VPWR rdata[29] sky130_fd_sc_hd__buf_2
Xoutput87 net87 VGND VGND VPWR VPWR rdata[19] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2670_ instance_0.mem\[0\]\[22\] _1067_ _1135_ instance_0.mem\[2\]\[22\] _1129_ VGND
+ VGND VPWR VPWR _1136_ sky130_fd_sc_hd__a221o_1
X_4340_ clknet_leaf_0_clk net276 VGND VGND VPWR VPWR instance_0.rdata\[62\] sky130_fd_sc_hd__dfxtp_1
X_4271_ clknet_leaf_0_clk _0107_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_3222_ _1531_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3153_ _1494_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
X_2104_ _0752_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3084_ net536 _1445_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3986_ _0952_ net593 _1947_ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__mux2_1
X_2937_ _1337_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4607_ clknet_leaf_19_clk _0443_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_2868_ instance_1.mem\[0\]\[0\] instance_1.mem\[1\]\[0\] instance_1.mem\[2\]\[0\]
+ instance_1.mem\[3\]\[0\] _1251_ _1205_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__mux4_1
Xhold320 instance_0.mem\[3\]\[68\] VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__dlygate4sd3_1
X_2799_ instance_0.mem\[1\]\[54\] _1218_ _1200_ instance_0.mem\[3\]\[54\] VGND VGND
+ VPWR VPWR _1233_ sky130_fd_sc_hd__a22o_1
Xhold331 instance_0.mem\[3\]\[61\] VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold342 instance_1.mem\[1\]\[56\] VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__dlygate4sd3_1
Xhold353 instance_1.mem\[1\]\[52\] VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__dlygate4sd3_1
X_4538_ clknet_leaf_14_clk _0374_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_4469_ clknet_leaf_19_clk _0305_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[47\] sky130_fd_sc_hd__dfxtp_1
Xhold375 instance_1.mem\[3\]\[63\] VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__dlygate4sd3_1
Xhold386 instance_0.mem\[1\]\[55\] VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__dlygate4sd3_1
Xhold364 instance_1.mem\[3\]\[40\] VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold397 instance_1.mem\[1\]\[49\] VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3840_ net711 net22 _1867_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__mux2_1
X_3771_ net422 net67 _1830_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2722_ instance_0.mem\[0\]\[35\] _1060_ _1153_ instance_0.mem\[3\]\[35\] VGND VGND
+ VPWR VPWR _1175_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2653_ _1059_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__buf_2
X_2584_ _1066_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__clkbuf_4
X_4323_ clknet_leaf_15_clk _0159_ VGND VGND VPWR VPWR instance_0.rdata\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4254_ clknet_leaf_8_clk _0090_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4185_ clknet_leaf_8_clk _0021_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_3205_ _1522_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
X_3136_ instance_1.mem\[0\]\[69\] instance_1.mem\[1\]\[69\] instance_1.mem\[2\]\[69\]
+ instance_1.mem\[3\]\[69\] _1041_ _1464_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__mux4_1
X_3067_ net309 _1430_ _1431_ _1434_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_53_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_61_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3969_ _0934_ net636 _1940_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold150 _0221_ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
Xhold161 instance_1.rdata\[48\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 _0143_ VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
Xhold172 _0181_ VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 instance_1.rdata\[19\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4872_ clknet_leaf_36_clk _0708_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_22_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3823_ net805 net13 _1860_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3754_ _1822_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__clkbuf_1
X_3685_ net389 _0969_ _1780_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_30_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2705_ _1042_ _1161_ instance_0.mem\[3\]\[31\] VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__and3_1
X_2636_ instance_0.mem\[0\]\[14\] instance_0.mem\[1\]\[14\] instance_0.mem\[2\]\[14\]
+ instance_0.mem\[3\]\[14\] _1069_ _1071_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__mux4_1
X_2567_ _1052_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__buf_2
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4306_ clknet_leaf_29_clk net212 VGND VGND VPWR VPWR instance_0.rdata\[28\] sky130_fd_sc_hd__dfxtp_1
X_2498_ _1003_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
X_4237_ clknet_leaf_24_clk _0073_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4168_ clknet_leaf_25_clk _0004_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_3119_ net615 _1471_ _1446_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__mux2_1
X_4099_ _0891_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__buf_2
XFILLER_0_77_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3470_ net553 _0913_ _1665_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__mux2_1
X_2421_ net19 VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__clkbuf_2
X_2352_ net15 VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__buf_1
X_2283_ net52 VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4022_ _0825_ net911 _1969_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4855_ clknet_leaf_49_clk _0691_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3806_ _1851_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__clkbuf_1
X_4786_ clknet_leaf_50_clk _0622_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3737_ _1813_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3668_ net457 _0952_ _1773_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__mux2_1
X_3599_ net964 _0880_ _1736_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__mux2_1
X_2619_ _1066_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_87_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2970_ _1077_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4640_ clknet_leaf_53_clk _0476_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4571_ clknet_leaf_37_clk _0407_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold705 instance_1.mem\[2\]\[39\] VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlygate4sd3_1
X_3522_ net671 _0965_ _1693_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold727 instance_0.mem\[0\]\[68\] VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__dlygate4sd3_1
Xhold716 instance_0.mem\[0\]\[48\] VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__dlygate4sd3_1
Xhold749 instance_1.mem\[2\]\[44\] VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__dlygate4sd3_1
X_3453_ _0894_ net859 _1656_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__mux2_1
Xhold738 instance_0.mem\[1\]\[32\] VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__dlygate4sd3_1
X_2404_ _0946_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
X_3384_ _1576_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__buf_2
X_2335_ net69 VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2266_ _0850_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4005_ _0971_ net530 _1954_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__mux2_1
X_2197_ instance_0.rdata\[68\] instance_1.rdata\[68\] _0800_ VGND VGND VPWR VPWR _0803_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_9_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4838_ clknet_leaf_5_clk _0674_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4769_ clknet_leaf_1_clk _0605_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold21 instance_0.rdata\[34\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 _0126_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 _0138_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 instance_0.rdata\[60\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 _0198_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 instance_1.rdata\[52\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold76 _0230_ VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 instance_0.rdata\[1\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 _0240_ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_7 _1278_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2120_ instance_0.rdata\[33\] instance_1.rdata\[33\] _0757_ VGND VGND VPWR VPWR _0761_
+ sky130_fd_sc_hd__mux2_1
X_2051_ instance_0.rdata\[1\] instance_1.rdata\[1\] _0722_ VGND VGND VPWR VPWR _0724_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2953_ _1066_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2884_ _1297_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__buf_2
X_4623_ clknet_leaf_3_clk _0459_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_4554_ clknet_leaf_60_clk _0390_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[60\] sky130_fd_sc_hd__dfxtp_1
Xhold502 instance_1.mem\[0\]\[66\] VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dlygate4sd3_1
Xhold513 instance_0.mem\[2\]\[41\] VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__dlygate4sd3_1
Xhold524 instance_0.mem\[1\]\[12\] VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__dlygate4sd3_1
Xhold535 instance_1.mem\[0\]\[17\] VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__dlygate4sd3_1
X_3505_ net426 _0947_ _1686_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__mux2_1
X_4485_ clknet_leaf_58_clk _0321_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[63\] sky130_fd_sc_hd__dfxtp_1
Xhold579 instance_1.mem\[3\]\[3\] VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dlygate4sd3_1
Xhold568 instance_0.mem\[2\]\[65\] VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dlygate4sd3_1
Xhold546 instance_1.mem\[1\]\[8\] VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__dlygate4sd3_1
Xhold557 instance_0.mem\[2\]\[17\] VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__dlygate4sd3_1
X_3436_ _1648_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__clkbuf_1
X_3367_ _0969_ net942 _1606_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2318_ net64 VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__buf_1
X_3298_ _0898_ net960 _1569_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2249_ _0812_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__buf_2
XFILLER_0_79_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput77 net77 VGND VGND VPWR VPWR rdata[0] sky130_fd_sc_hd__clkbuf_4
Xoutput99 net99 VGND VGND VPWR VPWR rdata[2] sky130_fd_sc_hd__clkbuf_4
Xoutput88 net88 VGND VGND VPWR VPWR rdata[1] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4270_ clknet_leaf_0_clk _0106_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_3221_ _0821_ net939 _1526_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__mux2_1
X_3152_ _0913_ net899 _1491_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__mux2_1
X_2103_ instance_0.rdata\[25\] instance_1.rdata\[25\] _0750_ VGND VGND VPWR VPWR _0752_
+ sky130_fd_sc_hd__mux2_1
X_3083_ _1286_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3985_ _1949_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2936_ net610 _1336_ _1288_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__mux2_1
X_2867_ net327 _1211_ _1282_ _1283_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__o22a_1
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4606_ clknet_leaf_7_clk _0442_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[40\] sky130_fd_sc_hd__dfxtp_1
Xhold310 instance_1.mem\[3\]\[6\] VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__dlygate4sd3_1
X_2798_ net271 _1227_ _1230_ _1232_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__o22a_1
X_4537_ clknet_leaf_15_clk _0373_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[43\] sky130_fd_sc_hd__dfxtp_1
Xhold343 instance_1.mem\[1\]\[44\] VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold332 instance_1.mem\[3\]\[65\] VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__dlygate4sd3_1
Xhold321 instance_1.mem\[3\]\[11\] VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__dlygate4sd3_1
Xhold387 instance_0.rdata\[39\] VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__dlygate4sd3_1
Xhold365 instance_0.mem\[2\]\[45\] VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__dlygate4sd3_1
Xhold376 instance_1.mem\[2\]\[27\] VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__dlygate4sd3_1
Xhold354 instance_1.mem\[3\]\[22\] VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__dlygate4sd3_1
X_4468_ clknet_leaf_9_clk _0304_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[46\] sky130_fd_sc_hd__dfxtp_1
Xhold398 instance_1.mem\[1\]\[11\] VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__dlygate4sd3_1
X_3419_ _1639_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__clkbuf_1
X_4399_ clknet_leaf_12_clk net292 VGND VGND VPWR VPWR instance_1.rdata\[49\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_28_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3770_ _1831_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__clkbuf_1
X_2721_ net169 _1171_ _1172_ _1174_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__o22a_1
XFILLER_0_13_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2652_ instance_0.mem\[3\]\[18\] _1119_ _1088_ instance_0.mem\[2\]\[18\] VGND VGND
+ VPWR VPWR _1122_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2583_ _1035_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__clkbuf_2
X_4322_ clknet_leaf_14_clk net242 VGND VGND VPWR VPWR instance_0.rdata\[44\] sky130_fd_sc_hd__dfxtp_1
X_4253_ clknet_leaf_20_clk _0089_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_51 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3204_ _0965_ net862 _1519_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__mux2_1
X_4184_ clknet_leaf_9_clk _0020_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3135_ net289 _1293_ _1481_ _1482_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__o22a_1
X_3066_ instance_1.mem\[1\]\[48\] _1418_ _1432_ instance_1.mem\[3\]\[48\] _1433_ VGND
+ VGND VPWR VPWR _1434_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_53_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3968_ _1925_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__clkbuf_4
X_2919_ _1324_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3899_ net936 net52 _1896_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__mux2_1
Xhold151 instance_1.rdata\[27\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
Xhold162 _0234_ VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 _0154_ VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
Xhold195 instance_1.rdata\[8\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 _0205_ VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold173 instance_1.rdata\[25\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_83_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4871_ clknet_leaf_41_clk _0707_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_46_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3822_ _1838_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__buf_2
XFILLER_0_27_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3753_ net970 net58 _1816_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3684_ _1784_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2704_ _1034_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__clkbuf_2
X_2635_ net369 _1104_ _1105_ _1109_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__o22a_1
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4305_ clknet_leaf_29_clk net368 VGND VGND VPWR VPWR instance_0.rdata\[27\] sky130_fd_sc_hd__dfxtp_1
X_2566_ _1036_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__buf_2
X_2497_ _0864_ net715 _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__mux2_1
X_4236_ clknet_leaf_24_clk _0072_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4167_ clknet_leaf_26_clk _0003_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3118_ instance_1.mem\[0\]\[63\] instance_1.mem\[1\]\[63\] instance_1.mem\[2\]\[63\]
+ instance_1.mem\[3\]\[63\] _1440_ _1464_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_27_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4098_ _2010_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3049_ net307 _1407_ _1420_ _1421_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__o22a_1
XFILLER_0_80_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_36_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_54_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2420_ _0957_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2351_ _0910_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
X_2282_ _0861_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_63_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4021_ _1968_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__buf_2
XFILLER_0_79_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_72_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4854_ clknet_leaf_56_clk _0690_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_4785_ clknet_leaf_50_clk _0621_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3805_ net749 net5 _1846_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3736_ net493 net50 _1809_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3667_ _1775_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__clkbuf_1
X_3598_ _1737_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__clkbuf_1
X_2618_ instance_0.mem\[3\]\[11\] _1094_ _1088_ instance_0.mem\[2\]\[11\] VGND VGND
+ VPWR VPWR _1095_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_81_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2549_ _1036_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__clkbuf_4
X_4219_ clknet_leaf_40_clk _0055_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_90_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_3_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4570_ clknet_leaf_50_clk _0406_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3521_ _1695_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__clkbuf_1
Xhold706 instance_0.mem\[3\]\[1\] VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlygate4sd3_1
Xhold728 instance_0.mem\[2\]\[23\] VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__dlygate4sd3_1
Xhold717 instance_0.mem\[1\]\[40\] VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3452_ _1657_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__clkbuf_1
Xhold739 instance_0.mem\[1\]\[20\] VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__dlygate4sd3_1
X_3383_ _1619_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__clkbuf_1
X_2403_ _0945_ net958 _0935_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__mux2_1
X_2334_ _0897_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
X_2265_ net385 _0849_ _0839_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__mux2_1
X_4004_ _1959_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__clkbuf_1
X_2196_ _0802_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4837_ clknet_leaf_2_clk _0673_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4768_ clknet_leaf_4_clk _0604_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_3719_ net926 net41 _1802_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__mux2_1
X_4699_ clknet_leaf_1_clk _0535_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[61\] sky130_fd_sc_hd__dfxtp_1
Xhold11 instance_0.rdata\[38\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 _0148_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 instance_0.rdata\[47\] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 instance_1.rdata\[22\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 _0238_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 _0174_ VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 _0115_ VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold99 instance_0.rdata\[2\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 instance_0.rdata\[23\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_8 _1335_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2050_ _0723_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2952_ _1076_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__buf_2
XFILLER_0_17_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2883_ _1296_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__buf_2
X_4622_ clknet_leaf_6_clk _0458_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4553_ clknet_leaf_1_clk _0389_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[59\] sky130_fd_sc_hd__dfxtp_1
Xhold536 instance_1.mem\[0\]\[26\] VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__dlygate4sd3_1
X_4484_ clknet_leaf_0_clk _0320_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[62\] sky130_fd_sc_hd__dfxtp_1
Xhold514 instance_1.mem\[3\]\[21\] VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__dlygate4sd3_1
X_3504_ _1664_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__buf_2
Xhold503 instance_0.mem\[0\]\[20\] VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__dlygate4sd3_1
Xhold525 instance_1.mem\[1\]\[32\] VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__dlygate4sd3_1
Xhold547 instance_1.mem\[1\]\[36\] VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__dlygate4sd3_1
X_3435_ _0875_ net901 _1642_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__mux2_1
Xhold558 instance_0.mem\[0\]\[22\] VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__dlygate4sd3_1
Xhold569 instance_0.mem\[2\]\[25\] VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlygate4sd3_1
X_3366_ _1610_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__clkbuf_1
X_2317_ _0885_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_3297_ _1572_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__clkbuf_1
X_2248_ net40 VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_0_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2179_ _0764_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__buf_2
XFILLER_0_79_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput78 net78 VGND VGND VPWR VPWR rdata[10] sky130_fd_sc_hd__clkbuf_4
Xoutput89 net89 VGND VGND VPWR VPWR rdata[20] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_59_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3220_ _1530_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
X_3151_ _1493_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
X_2102_ _0751_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__buf_1
X_3082_ instance_1.mem\[0\]\[53\] instance_1.mem\[1\]\[53\] instance_1.mem\[2\]\[53\]
+ instance_1.mem\[3\]\[53\] _1440_ _1375_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__mux4_1
XFILLER_0_76_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3984_ _0950_ net852 _1947_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__mux2_1
X_2935_ instance_1.mem\[0\]\[15\] instance_1.mem\[1\]\[15\] instance_1.mem\[2\]\[15\]
+ instance_1.mem\[3\]\[15\] _1335_ _1290_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__mux4_1
X_2866_ instance_0.mem\[1\]\[71\] _1260_ _1241_ instance_0.mem\[0\]\[71\] _1266_ VGND
+ VGND VPWR VPWR _1283_ sky130_fd_sc_hd__a221o_1
XFILLER_0_60_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4605_ clknet_leaf_17_clk _0441_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[39\] sky130_fd_sc_hd__dfxtp_1
Xhold311 instance_1.mem\[2\]\[71\] VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold300 instance_1.mem\[3\]\[9\] VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2797_ instance_0.mem\[0\]\[53\] _1202_ _1231_ instance_0.mem\[2\]\[53\] _1203_ VGND
+ VGND VPWR VPWR _1232_ sky130_fd_sc_hd__a221o_1
X_4536_ clknet_leaf_17_clk _0372_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[42\] sky130_fd_sc_hd__dfxtp_1
Xhold333 instance_1.mem\[3\]\[30\] VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__dlygate4sd3_1
Xhold322 instance_1.mem\[0\]\[65\] VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__dlygate4sd3_1
Xhold344 instance_0.mem\[2\]\[14\] VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4467_ clknet_leaf_14_clk _0303_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[45\] sky130_fd_sc_hd__dfxtp_1
Xhold355 instance_0.mem\[1\]\[30\] VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__dlygate4sd3_1
Xhold366 instance_1.mem\[1\]\[2\] VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__dlygate4sd3_1
Xhold377 instance_1.mem\[1\]\[68\] VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_90_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold399 instance_1.mem\[1\]\[39\] VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__dlygate4sd3_1
Xhold388 instance_1.rdata\[53\] VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__dlygate4sd3_1
X_3418_ _0858_ net828 _1635_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__mux2_1
X_4398_ clknet_leaf_8_clk net310 VGND VGND VPWR VPWR instance_1.rdata\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3349_ _1601_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_56_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2720_ instance_0.mem\[1\]\[34\] _1173_ _1169_ instance_0.mem\[0\]\[34\] _1151_ VGND
+ VGND VPWR VPWR _1174_ sky130_fd_sc_hd__a221o_1
X_2651_ net329 _1104_ _1120_ _1121_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__o22a_1
XFILLER_0_54_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2582_ instance_0.mem\[1\]\[5\] _1028_ _1048_ instance_0.mem\[3\]\[5\] VGND VGND
+ VPWR VPWR _1065_ sky130_fd_sc_hd__a22o_1
X_4321_ clknet_leaf_15_clk _0157_ VGND VGND VPWR VPWR instance_0.rdata\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4252_ clknet_leaf_9_clk _0088_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3203_ _1521_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
X_4183_ clknet_leaf_12_clk _0019_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_3134_ instance_1.mem\[0\]\[68\] _1052_ _1450_ instance_1.mem\[2\]\[68\] _1301_ VGND
+ VGND VPWR VPWR _1482_ sky130_fd_sc_hd__a221o_1
X_3065_ _1297_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__buf_2
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3967_ _1939_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__clkbuf_1
X_2918_ net449 _1323_ _1288_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_30_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_30_clk sky130_fd_sc_hd__clkbuf_8
X_3898_ _1901_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__clkbuf_1
X_2849_ _1036_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__buf_2
Xhold152 _0213_ VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
Xhold141 instance_1.rdata\[68\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
Xhold130 _0241_ VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
X_4519_ clknet_leaf_35_clk _0355_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
Xhold163 instance_1.rdata\[61\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold185 instance_1.rdata\[37\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold174 _0211_ VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold196 _0194_ VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_69_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_21_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_63_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4870_ clknet_leaf_38_clk _0706_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_3821_ _1859_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3752_ _1821_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_12_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
X_3683_ net524 _0967_ _1780_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__mux2_1
X_2703_ instance_0.mem\[2\]\[31\] _1100_ _1031_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2634_ instance_0.mem\[1\]\[13\] _1106_ _1108_ instance_0.mem\[3\]\[13\] _1091_ VGND
+ VGND VPWR VPWR _1109_ sky130_fd_sc_hd__a221o_1
X_2565_ net235 _1026_ _1049_ _1051_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__o22a_1
XFILLER_0_10_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4304_ clknet_leaf_31_clk net178 VGND VGND VPWR VPWR instance_0.rdata\[26\] sky130_fd_sc_hd__dfxtp_1
X_2496_ _0980_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__clkbuf_4
X_4235_ clknet_leaf_29_clk _0071_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4166_ clknet_leaf_23_clk _0002_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_3117_ _1470_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4097_ _0902_ net696 _2004_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3048_ instance_1.mem\[0\]\[43\] _1401_ _1396_ instance_1.mem\[2\]\[43\] _1410_ VGND
+ VGND VPWR VPWR _1421_ sky130_fd_sc_hd__a221o_1
XFILLER_0_18_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2350_ _0904_ net880 _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_9_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2281_ net501 _0860_ _0852_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_1_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
X_4020_ _1924_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__buf_2
XFILLER_0_29_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4853_ clknet_leaf_56_clk _0689_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_3804_ _1850_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__clkbuf_1
X_4784_ clknet_leaf_53_clk _0620_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_3735_ _1812_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3666_ net797 _0950_ _1773_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__mux2_1
X_3597_ net404 _0877_ _1736_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__mux2_1
X_2617_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__buf_2
X_2548_ _1035_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4218_ clknet_leaf_38_clk _0054_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_2479_ _0847_ net659 _0988_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_87_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4149_ net730 net19 _2032_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_438 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3520_ net446 _0963_ _1693_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold707 instance_0.mem\[0\]\[25\] VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlygate4sd3_1
Xhold718 instance_0.mem\[0\]\[49\] VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dlygate4sd3_1
Xhold729 instance_0.mem\[3\]\[41\] VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__dlygate4sd3_1
X_3451_ _0890_ net831 _1656_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__mux2_1
X_3382_ _0823_ net566 _1613_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2402_ net12 VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_20_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2333_ net525 _0896_ _0892_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__mux2_1
X_2264_ net45 VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__buf_1
X_4003_ _0969_ net428 _1954_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__mux2_1
X_2195_ instance_0.rdata\[67\] instance_1.rdata\[67\] _0800_ VGND VGND VPWR VPWR _0802_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4836_ clknet_leaf_3_clk _0672_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4767_ clknet_leaf_3_clk _0603_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_3718_ _1803_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4698_ clknet_leaf_60_clk _0534_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3649_ _1765_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold12 _0152_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 instance_0.rdata\[11\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 _0161_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 instance_0.rdata\[57\] VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 _0208_ VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
Xhold89 instance_1.rdata\[4\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 instance_0.rdata\[18\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 _0137_ VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_9 wdata[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2951_ instance_1.mem\[3\]\[19\] _1320_ _1329_ instance_1.mem\[2\]\[19\] VGND VGND
+ VPWR VPWR _1348_ sky130_fd_sc_hd__a22o_1
XFILLER_0_84_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4621_ clknet_leaf_2_clk _0457_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_2882_ _0720_ _0808_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4552_ clknet_leaf_7_clk _0388_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold526 instance_0.mem\[0\]\[39\] VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__dlygate4sd3_1
Xhold515 instance_0.mem\[2\]\[47\] VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__dlygate4sd3_1
Xhold504 instance_0.mem\[0\]\[3\] VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__dlygate4sd3_1
X_4483_ clknet_leaf_0_clk _0319_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_3503_ _1685_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__clkbuf_1
Xhold548 instance_1.mem\[0\]\[71\] VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__dlygate4sd3_1
Xhold537 instance_1.mem\[1\]\[9\] VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dlygate4sd3_1
Xhold559 instance_1.mem\[1\]\[64\] VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__dlygate4sd3_1
X_3434_ _1647_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3365_ _0967_ net930 _1606_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2316_ net494 _0884_ _0878_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
X_3296_ _0896_ net800 _1569_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__mux2_1
X_2247_ _0837_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2178_ _0792_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_51_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4819_ clknet_leaf_21_clk _0655_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput79 net79 VGND VGND VPWR VPWR rdata[11] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_41_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3150_ _0911_ net931 _1491_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3081_ net191 _1430_ _1443_ _1444_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__o22a_1
X_2101_ instance_0.rdata\[24\] instance_1.rdata\[24\] _0750_ VGND VGND VPWR VPWR _0751_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3983_ _1948_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__clkbuf_1
X_2934_ _1033_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__buf_4
X_2865_ instance_0.mem\[3\]\[71\] _1177_ _1268_ instance_0.mem\[2\]\[71\] VGND VGND
+ VPWR VPWR _1282_ sky130_fd_sc_hd__a22o_1
X_4604_ clknet_leaf_18_clk _0440_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[38\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4535_ clknet_leaf_18_clk _0371_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[41\] sky130_fd_sc_hd__dfxtp_1
Xhold301 instance_1.rdata\[10\] VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2796_ _1098_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__clkbuf_4
Xhold334 instance_0.rdata\[6\] VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__dlygate4sd3_1
Xhold323 instance_1.mem\[2\]\[62\] VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__dlygate4sd3_1
Xhold312 instance_1.mem\[0\]\[0\] VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__dlygate4sd3_1
Xhold378 instance_1.mem\[1\]\[29\] VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__dlygate4sd3_1
X_4466_ clknet_leaf_14_clk _0302_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[44\] sky130_fd_sc_hd__dfxtp_1
Xhold367 instance_1.mem\[0\]\[63\] VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__dlygate4sd3_1
Xhold356 instance_0.mem\[1\]\[56\] VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__dlygate4sd3_1
Xhold345 instance_1.mem\[2\]\[51\] VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__dlygate4sd3_1
Xhold389 instance_1.mem\[3\]\[34\] VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__dlygate4sd3_1
X_4397_ clknet_leaf_16_clk _0233_ VGND VGND VPWR VPWR instance_1.rdata\[47\] sky130_fd_sc_hd__dfxtp_1
X_3417_ _1638_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3348_ _0950_ net912 _1599_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__mux2_1
X_3279_ _0877_ net564 _1562_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2650_ instance_0.mem\[1\]\[17\] _1106_ _1096_ instance_0.mem\[0\]\[17\] _1091_ VGND
+ VGND VPWR VPWR _1121_ sky130_fd_sc_hd__a221o_1
XFILLER_0_81_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2581_ net285 _1026_ _1063_ _1064_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__o22a_1
X_4320_ clknet_leaf_17_clk net200 VGND VGND VPWR VPWR instance_0.rdata\[42\] sky130_fd_sc_hd__dfxtp_1
X_4251_ clknet_leaf_15_clk _0087_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[45\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3202_ _0963_ net813 _1519_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__mux2_1
X_4182_ clknet_leaf_9_clk _0018_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_3133_ instance_1.mem\[1\]\[68\] _1448_ _1094_ instance_1.mem\[3\]\[68\] VGND VGND
+ VPWR VPWR _1481_ sky130_fd_sc_hd__a22o_1
X_3064_ _1107_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__buf_2
XFILLER_0_54_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3966_ _0932_ net737 _1933_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__mux2_1
X_2917_ instance_1.mem\[0\]\[10\] instance_1.mem\[1\]\[10\] instance_1.mem\[2\]\[10\]
+ instance_1.mem\[3\]\[10\] _1251_ _1290_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_61_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3897_ net834 net51 _1896_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__mux2_1
X_2848_ instance_0.mem\[1\]\[67\] _1218_ _1268_ instance_0.mem\[2\]\[67\] VGND VGND
+ VPWR VPWR _1269_ sky130_fd_sc_hd__a22o_1
X_2779_ _1077_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__clkbuf_4
Xhold153 instance_1.rdata\[42\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 instance_0.rdata\[69\] VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 _0122_ VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
Xhold142 _0254_ VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
X_4518_ clknet_leaf_35_clk _0354_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4449_ clknet_leaf_29_clk _0285_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold164 _0247_ VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
Xhold175 instance_0.rdata\[16\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold186 _0223_ VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold197 instance_1.rdata\[26\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_69_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3820_ net851 net12 _1853_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3751_ net528 net57 _1816_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__mux2_1
X_2702_ _1159_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3682_ _1783_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2633_ _1107_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__buf_4
XFILLER_0_42_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2564_ instance_0.mem\[0\]\[1\] _1037_ _1040_ instance_0.mem\[2\]\[1\] _1050_ VGND
+ VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a221o_1
XFILLER_0_2_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4303_ clknet_leaf_31_clk net282 VGND VGND VPWR VPWR instance_0.rdata\[25\] sky130_fd_sc_hd__dfxtp_1
X_2495_ _1001_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
X_4234_ clknet_leaf_29_clk _0070_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4165_ clknet_leaf_23_clk _0001_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_3116_ net627 _1469_ _1446_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4096_ _2009_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__clkbuf_1
X_3047_ instance_1.mem\[1\]\[43\] _1362_ _1394_ instance_1.mem\[3\]\[43\] VGND VGND
+ VPWR VPWR _1420_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_38_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3949_ _0915_ net689 _1926_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2280_ net51 VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__buf_1
XFILLER_0_35_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4852_ clknet_leaf_53_clk _0688_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[70\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3803_ net488 net75 _1846_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4783_ clknet_leaf_49_clk _0619_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3734_ net603 net49 _1809_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__mux2_1
X_3665_ _1774_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2616_ _1046_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__buf_2
X_3596_ _1707_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__clkbuf_4
X_2547_ _1033_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__nor2_1
X_2478_ _0992_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
X_4217_ clknet_leaf_51_clk _0053_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4148_ _2037_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__clkbuf_1
X_4079_ _2000_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold719 instance_1.mem\[2\]\[35\] VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dlygate4sd3_1
Xhold708 instance_1.mem\[2\]\[49\] VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__dlygate4sd3_1
X_3450_ _1620_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__buf_2
X_3381_ _1618_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__clkbuf_1
X_2401_ _0944_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
X_2332_ net68 VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__clkbuf_2
X_4002_ _1958_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__clkbuf_1
X_2263_ _0848_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
X_2194_ _0801_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_48_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4835_ clknet_leaf_10_clk _0671_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_4766_ clknet_leaf_5_clk _0602_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_3717_ net489 net40 _1802_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__mux2_1
X_4697_ clknet_leaf_1_clk _0533_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_3648_ net622 _0932_ _1759_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__mux2_1
X_3579_ net799 _0860_ _1722_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__mux2_1
Xhold13 instance_0.rdata\[65\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 instance_0.rdata\[10\] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 _0125_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 _0171_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 instance_1.rdata\[38\] VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 instance_1.rdata\[13\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 _0132_ VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2950_ _1346_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__buf_2
XFILLER_0_84_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2881_ instance_1.mem\[3\]\[2\] _1177_ _1268_ instance_1.mem\[2\]\[2\] VGND VGND
+ VPWR VPWR _1295_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4620_ clknet_leaf_10_clk _0456_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_4551_ clknet_leaf_3_clk _0387_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[57\] sky130_fd_sc_hd__dfxtp_1
Xhold516 instance_1.mem\[3\]\[39\] VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__dlygate4sd3_1
X_4482_ clknet_leaf_60_clk _0318_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[60\] sky130_fd_sc_hd__dfxtp_1
Xhold527 instance_1.mem\[1\]\[55\] VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__dlygate4sd3_1
X_3502_ net656 _0945_ _1679_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__mux2_1
Xhold505 instance_1.mem\[1\]\[53\] VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dlygate4sd3_1
Xhold538 instance_0.mem\[3\]\[35\] VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__dlygate4sd3_1
X_3433_ _0873_ net720 _1642_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__mux2_1
Xhold549 instance_0.mem\[2\]\[24\] VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dlygate4sd3_1
X_3364_ _1609_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__clkbuf_1
X_3295_ _1571_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__clkbuf_1
X_2315_ net63 VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2246_ net472 _0836_ _0826_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_69_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2177_ instance_0.rdata\[59\] instance_1.rdata\[59\] _0786_ VGND VGND VPWR VPWR _0792_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_51_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4818_ clknet_leaf_19_clk _0654_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_239 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4749_ clknet_leaf_17_clk _0585_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[39\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_78_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3080_ instance_1.mem\[0\]\[52\] _1401_ _1396_ instance_1.mem\[2\]\[52\] _1433_ VGND
+ VGND VPWR VPWR _1444_ sky130_fd_sc_hd__a221o_1
X_2100_ _0721_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__buf_2
XFILLER_0_27_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3982_ _0947_ net565 _1947_ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__mux2_1
X_2933_ _1334_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2864_ net259 _1211_ _1280_ _1281_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__o22a_1
X_2795_ instance_0.mem\[1\]\[53\] _1218_ _1200_ instance_0.mem\[3\]\[53\] VGND VGND
+ VPWR VPWR _1230_ sky130_fd_sc_hd__a22o_1
X_4603_ clknet_leaf_22_clk _0439_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[37\] sky130_fd_sc_hd__dfxtp_1
Xhold302 instance_0.mem\[3\]\[28\] VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__dlygate4sd3_1
X_4534_ clknet_leaf_21_clk _0370_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[40\] sky130_fd_sc_hd__dfxtp_1
Xhold324 instance_1.mem\[1\]\[41\] VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__dlygate4sd3_1
Xhold335 instance_1.mem\[2\]\[65\] VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__dlygate4sd3_1
Xhold313 instance_1.mem\[2\]\[6\] VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4465_ clknet_leaf_15_clk _0301_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[43\] sky130_fd_sc_hd__dfxtp_1
Xhold357 instance_1.mem\[3\]\[47\] VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__dlygate4sd3_1
Xhold346 instance_1.mem\[1\]\[63\] VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold368 instance_1.mem\[1\]\[57\] VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__dlygate4sd3_1
Xhold379 instance_0.mem\[2\]\[1\] VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3416_ _0856_ net892 _1635_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__mux2_1
X_4396_ clknet_leaf_20_clk _0232_ VGND VGND VPWR VPWR instance_1.rdata\[46\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_90_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3347_ _1600_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3278_ _1533_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__buf_2
X_2229_ net33 VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_56_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2580_ instance_0.mem\[3\]\[4\] _1047_ _1040_ instance_0.mem\[2\]\[4\] _1057_ VGND
+ VGND VPWR VPWR _1064_ sky130_fd_sc_hd__a221o_1
X_4250_ clknet_leaf_14_clk _0086_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4181_ clknet_leaf_16_clk _0017_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_3201_ _1520_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
X_3132_ _1480_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
X_3063_ instance_1.mem\[0\]\[48\] _1371_ _1408_ instance_1.mem\[2\]\[48\] VGND VGND
+ VPWR VPWR _1431_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3965_ _1938_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2916_ net209 _1319_ _1321_ _1322_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__o22a_1
X_3896_ _1900_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_61_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2847_ _1087_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold110 _0162_ VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
X_2778_ net257 _1193_ _1214_ _1217_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__o22a_1
Xhold132 _0183_ VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
Xhold121 instance_1.rdata\[64\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
X_4517_ clknet_leaf_36_clk _0353_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold143 instance_1.rdata\[49\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 _0228_ VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold176 _0130_ VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
Xhold165 instance_0.rdata\[54\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
X_4448_ clknet_leaf_31_clk _0284_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold198 _0212_ VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold187 instance_1.rdata\[32\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
X_4379_ clknet_leaf_30_clk net318 VGND VGND VPWR VPWR instance_1.rdata\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_69_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3750_ _1820_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2701_ net776 _1158_ _1111_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3681_ net774 _0965_ _1780_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__mux2_1
X_2632_ _1046_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__buf_2
XFILLER_0_2_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2563_ _1029_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4302_ clknet_leaf_35_clk net180 VGND VGND VPWR VPWR instance_0.rdata\[24\] sky130_fd_sc_hd__dfxtp_1
X_4233_ clknet_leaf_29_clk _0069_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_2494_ _0862_ net900 _0995_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__mux2_1
X_4164_ clknet_leaf_25_clk _0000_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3115_ instance_1.mem\[0\]\[62\] instance_1.mem\[1\]\[62\] instance_1.mem\[2\]\[62\]
+ instance_1.mem\[3\]\[62\] _1440_ _1464_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__mux4_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4095_ _0900_ net645 _2004_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__mux2_1
X_3046_ net301 _1407_ _1417_ _1419_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_66_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3948_ _1929_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__clkbuf_1
X_3879_ _1891_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_14_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_23_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_32_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4851_ clknet_leaf_56_clk _0687_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3802_ _1849_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__clkbuf_1
X_4782_ clknet_leaf_49_clk _0618_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3733_ _1811_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_41_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3664_ net414 _0947_ _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__mux2_1
X_2615_ net183 _1075_ _1089_ _1092_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__o22a_1
X_3595_ _1735_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__clkbuf_1
X_2546_ _0809_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__clkbuf_2
X_2477_ _0845_ net606 _0988_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__mux2_1
X_4216_ clknet_leaf_46_clk _0052_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_50_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4147_ net435 net18 _2032_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_87_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4078_ _0882_ net613 _1997_ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__mux2_1
X_3029_ net205 _1388_ _1404_ _1406_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__o22a_1
XFILLER_0_38_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold709 instance_1.mem\[1\]\[13\] VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__dlygate4sd3_1
X_2400_ _0943_ net747 _0935_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__mux2_1
X_3380_ _0821_ net724 _1613_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__mux2_1
X_2331_ _0895_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
X_2262_ net378 _0847_ _0839_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__mux2_1
X_4001_ _0967_ net634 _1954_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__mux2_1
X_2193_ instance_0.rdata\[66\] instance_1.rdata\[66\] _0800_ VGND VGND VPWR VPWR _0801_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4834_ clknet_leaf_9_clk _0670_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_4765_ clknet_leaf_2_clk _0601_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3716_ _1794_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__buf_2
X_4696_ clknet_leaf_4_clk _0532_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_3647_ _1764_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3578_ _1726_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__clkbuf_1
X_2529_ _0898_ net890 _1016_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__mux2_1
Xhold14 _0179_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 _0124_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 instance_1.rdata\[58\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 instance_0.rdata\[20\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 _0224_ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold69 instance_1.rdata\[16\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_7_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2880_ _1293_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__buf_2
XFILLER_0_4_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4550_ clknet_leaf_6_clk _0386_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold517 instance_0.mem\[1\]\[57\] VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dlygate4sd3_1
X_4481_ clknet_leaf_2_clk _0317_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_3501_ _1684_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__clkbuf_1
Xhold506 instance_0.mem\[1\]\[22\] VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__dlygate4sd3_1
Xhold539 instance_1.mem\[1\]\[28\] VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__dlygate4sd3_1
X_3432_ _1646_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__clkbuf_1
Xhold528 instance_0.mem\[3\]\[20\] VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__dlygate4sd3_1
X_3363_ _0965_ net678 _1606_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3294_ _0894_ net933 _1569_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__mux2_1
X_2314_ _0883_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_2245_ net39 VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_32_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2176_ _0791_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_1
XFILLER_0_73_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4817_ clknet_leaf_25_clk _0653_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_60_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_60_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_90_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4748_ clknet_leaf_18_clk _0584_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_4679_ clknet_leaf_19_clk _0515_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_51_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_51_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_26_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_407 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3981_ _1925_ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__buf_2
XFILLER_0_57_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2932_ net896 _1333_ _1288_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_42_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_42_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2863_ instance_0.mem\[0\]\[70\] _1270_ _1274_ instance_0.mem\[2\]\[70\] _1266_ VGND
+ VGND VPWR VPWR _1281_ sky130_fd_sc_hd__a221o_1
X_4602_ clknet_leaf_19_clk _0438_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_2794_ net273 _1227_ _1228_ _1229_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__o22a_1
X_4533_ clknet_leaf_17_clk _0369_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold314 instance_1.mem\[1\]\[15\] VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__dlygate4sd3_1
Xhold325 instance_1.mem\[2\]\[57\] VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold303 instance_1.mem\[3\]\[56\] VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__dlygate4sd3_1
X_4464_ clknet_leaf_17_clk _0300_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[42\] sky130_fd_sc_hd__dfxtp_1
Xhold369 instance_0.mem\[3\]\[44\] VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__dlygate4sd3_1
Xhold336 instance_0.mem\[1\]\[65\] VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold358 instance_1.mem\[2\]\[32\] VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__dlygate4sd3_1
Xhold347 instance_1.mem\[1\]\[25\] VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__dlygate4sd3_1
X_4395_ clknet_leaf_15_clk net306 VGND VGND VPWR VPWR instance_1.rdata\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3415_ _1637_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_90_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3346_ _0947_ net914 _1599_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3277_ _1561_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__clkbuf_1
X_2228_ _0824_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_56_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2159_ _0782_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_33_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_33_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_24_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_81_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3200_ _0960_ net794 _1519_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__mux2_1
X_4180_ clknet_leaf_13_clk _0016_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_3131_ net455 _1479_ _1446_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__mux2_1
X_3062_ _1346_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__buf_2
XFILLER_0_49_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_15_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
X_3964_ _0930_ net550 _1933_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2915_ instance_1.mem\[1\]\[9\] _1315_ _1241_ instance_1.mem\[0\]\[9\] _1302_ VGND
+ VGND VPWR VPWR _1322_ sky130_fd_sc_hd__a221o_1
XFILLER_0_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3895_ net959 net50 _1896_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_61_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2846_ net221 _1248_ _1265_ _1267_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__o22a_1
XFILLER_0_5_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold100 _0116_ VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
X_2777_ instance_0.mem\[1\]\[48\] _1215_ _1169_ instance_0.mem\[0\]\[48\] _1216_ VGND
+ VGND VPWR VPWR _1217_ sky130_fd_sc_hd__a221o_1
XFILLER_0_79_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold111 instance_0.rdata\[70\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
Xhold122 _0250_ VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
X_4516_ clknet_leaf_33_clk _0352_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
Xhold144 _0235_ VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 instance_0.rdata\[25\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
Xhold177 instance_1.rdata\[11\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
Xhold166 _0168_ VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 instance_1.rdata\[50\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
X_4447_ clknet_leaf_35_clk _0283_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
Xhold199 instance_1.rdata\[30\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
Xhold188 _0218_ VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
X_4378_ clknet_leaf_29_clk _0214_ VGND VGND VPWR VPWR instance_1.rdata\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_69_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3329_ _1590_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2700_ instance_0.mem\[0\]\[30\] instance_0.mem\[1\]\[30\] instance_0.mem\[2\]\[30\]
+ instance_0.mem\[3\]\[30\] _1069_ _1071_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__mux4_1
X_3680_ _1782_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2631_ _1055_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__buf_2
X_2562_ instance_0.mem\[1\]\[1\] _1028_ _1048_ instance_0.mem\[3\]\[1\] VGND VGND
+ VPWR VPWR _1049_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4301_ clknet_leaf_36_clk net226 VGND VGND VPWR VPWR instance_0.rdata\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2493_ _1000_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
X_4232_ clknet_leaf_31_clk _0068_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_4_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_4163_ _2045_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__clkbuf_1
X_4094_ _2008_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__clkbuf_1
X_3114_ net311 _1454_ _1467_ _1468_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__o22a_1
X_3045_ instance_1.mem\[1\]\[42\] _1418_ _1405_ instance_1.mem\[0\]\[42\] _1410_ VGND
+ VGND VPWR VPWR _1419_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_66_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3947_ _0913_ net725 _1926_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3878_ net424 net41 _1889_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__mux2_1
X_2829_ instance_0.mem\[1\]\[62\] _1215_ _1241_ instance_0.mem\[0\]\[62\] _1242_ VGND
+ VGND VPWR VPWR _1255_ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_35_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4850_ clknet_leaf_53_clk _0686_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[68\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_71_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3801_ net431 net74 _1846_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__mux2_1
X_4781_ clknet_leaf_56_clk _0617_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3732_ net856 net47 _1809_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3663_ _1751_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__buf_2
X_2614_ instance_0.mem\[1\]\[10\] _1056_ _1090_ instance_0.mem\[3\]\[10\] _1091_ VGND
+ VGND VPWR VPWR _1092_ sky130_fd_sc_hd__a221o_1
X_3594_ net723 _0875_ _1729_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__mux2_1
X_2545_ _0906_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_62_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2476_ _0991_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
X_4215_ clknet_leaf_44_clk _0051_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_4146_ _2036_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_87_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4077_ _1999_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__clkbuf_1
X_3028_ instance_1.mem\[1\]\[38\] _1385_ _1405_ instance_1.mem\[0\]\[38\] _1386_ VGND
+ VGND VPWR VPWR _1406_ sky130_fd_sc_hd__a221o_1
XFILLER_0_78_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2330_ net410 _0894_ _0892_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__mux2_1
X_2261_ net44 VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4000_ _1957_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__clkbuf_1
X_2192_ _0764_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__buf_2
XFILLER_0_27_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4833_ clknet_leaf_8_clk _0669_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_4764_ clknet_leaf_2_clk _0600_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_3715_ _1801_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4695_ clknet_leaf_3_clk _0531_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3646_ net386 _0930_ _1759_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3577_ net412 _0858_ _1722_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2528_ _1019_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
X_2459_ _0982_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
Xhold26 _0244_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 instance_1.rdata\[5\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 instance_0.rdata\[49\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold59 instance_0.rdata\[64\] VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 _0134_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
X_4129_ _2027_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_82_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3500_ net567 _0943_ _1679_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__mux2_1
Xhold507 instance_0.mem\[2\]\[33\] VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__dlygate4sd3_1
X_4480_ clknet_leaf_4_clk _0316_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[58\] sky130_fd_sc_hd__dfxtp_1
Xhold518 instance_1.mem\[1\]\[17\] VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__dlygate4sd3_1
X_3431_ _0871_ net940 _1642_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__mux2_1
Xhold529 instance_0.mem\[0\]\[55\] VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3362_ _1608_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__clkbuf_1
X_2313_ net407 _0882_ _0878_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3293_ _1570_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__clkbuf_1
X_2244_ _0835_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2175_ instance_0.rdata\[58\] instance_1.rdata\[58\] _0786_ VGND VGND VPWR VPWR _0791_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4816_ clknet_leaf_26_clk _0652_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4747_ clknet_leaf_21_clk _0583_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_4678_ clknet_leaf_21_clk _0514_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_3629_ net768 _0913_ _1752_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3980_ _1946_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2931_ net752 instance_1.mem\[1\]\[14\] instance_1.mem\[2\]\[14\] instance_1.mem\[3\]\[14\]
+ _1251_ _1290_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__mux4_1
XFILLER_0_57_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4601_ clknet_leaf_25_clk _0437_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_2862_ instance_0.mem\[1\]\[70\] _1272_ _1262_ instance_0.mem\[3\]\[70\] VGND VGND
+ VPWR VPWR _1280_ sky130_fd_sc_hd__a22o_1
X_2793_ instance_0.mem\[1\]\[52\] _1215_ _1169_ instance_0.mem\[0\]\[52\] _1203_ VGND
+ VGND VPWR VPWR _1229_ sky130_fd_sc_hd__a221o_1
X_4532_ clknet_leaf_18_clk _0368_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4463_ clknet_leaf_19_clk _0299_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[41\] sky130_fd_sc_hd__dfxtp_1
Xhold315 instance_0.mem\[0\]\[47\] VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold326 instance_0.mem\[0\]\[56\] VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__dlygate4sd3_1
Xhold304 instance_0.mem\[2\]\[46\] VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__dlygate4sd3_1
Xhold348 instance_1.mem\[3\]\[46\] VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_469 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold359 instance_1.mem\[3\]\[53\] VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__dlygate4sd3_1
X_3414_ _0854_ net891 _1635_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__mux2_1
Xhold337 instance_1.mem\[3\]\[31\] VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__dlygate4sd3_1
X_4394_ clknet_leaf_13_clk net224 VGND VGND VPWR VPWR instance_1.rdata\[44\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3345_ _1577_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__buf_2
X_3276_ _0875_ net442 _1555_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__mux2_1
X_2227_ net814 _0823_ _0813_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2158_ instance_0.rdata\[50\] instance_1.rdata\[50\] _0779_ VGND VGND VPWR VPWR _0782_
+ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2089_ _0744_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__buf_1
XFILLER_0_48_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3130_ instance_1.mem\[0\]\[67\] instance_1.mem\[1\]\[67\] instance_1.mem\[2\]\[67\]
+ instance_1.mem\[3\]\[67\] _1041_ _1464_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__mux4_1
X_3061_ _1429_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3963_ _1937_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__clkbuf_1
X_2914_ instance_1.mem\[3\]\[9\] _1320_ _1268_ instance_1.mem\[2\]\[9\] VGND VGND
+ VPWR VPWR _1321_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3894_ _1899_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_61_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2845_ instance_0.mem\[1\]\[66\] _1260_ _1231_ instance_0.mem\[2\]\[66\] _1266_ VGND
+ VGND VPWR VPWR _1267_ sky130_fd_sc_hd__a221o_1
XFILLER_0_60_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold101 instance_1.rdata\[33\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_5_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4515_ clknet_leaf_34_clk _0351_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_2776_ _1165_ _1161_ instance_0.mem\[3\]\[48\] VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold112 _0184_ VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 instance_0.rdata\[53\] VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 _0139_ VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 instance_0.rdata\[3\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
Xhold167 instance_1.rdata\[21\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 _0236_ VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
X_4446_ clknet_leaf_35_clk _0282_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4377_ clknet_leaf_30_clk net300 VGND VGND VPWR VPWR instance_1.rdata\[27\] sky130_fd_sc_hd__dfxtp_1
Xhold178 _0197_ VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
Xhold189 instance_1.rdata\[70\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
X_3328_ _0930_ net827 _1585_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3259_ _0858_ net781 _1548_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold690 instance_0.mem\[3\]\[4\] VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2630_ instance_0.mem\[0\]\[13\] _1060_ _1088_ instance_0.mem\[2\]\[13\] VGND VGND
+ VPWR VPWR _1105_ sky130_fd_sc_hd__a22o_1
X_2561_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__buf_2
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2492_ _0860_ net952 _0995_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__mux2_1
X_4300_ clknet_leaf_33_clk net254 VGND VGND VPWR VPWR instance_0.rdata\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4231_ clknet_leaf_31_clk _0067_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4162_ net526 net25 _2039_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__mux2_1
X_4093_ _0898_ net719 _2004_ VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__mux2_1
X_3113_ instance_1.mem\[0\]\[61\] _1401_ _1450_ instance_1.mem\[2\]\[61\] _1456_ VGND
+ VGND VPWR VPWR _1468_ sky130_fd_sc_hd__a221o_1
X_3044_ _1076_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__buf_2
XFILLER_0_65_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3946_ _1928_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3877_ _1890_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__clkbuf_1
X_2828_ instance_0.mem\[3\]\[62\] _1177_ _1190_ instance_0.mem\[2\]\[62\] VGND VGND
+ VPWR VPWR _1254_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2759_ _1029_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__buf_2
X_4429_ clknet_leaf_47_clk _0265_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3800_ _1848_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__clkbuf_1
X_4780_ clknet_leaf_54_clk _0616_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[70\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_71_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3731_ _1810_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__clkbuf_1
X_3662_ _1772_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__clkbuf_1
X_3593_ _1734_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__clkbuf_1
X_2613_ _1030_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__buf_2
X_2544_ instance_0.mem\[1\]\[0\] _1028_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__a21o_1
X_2475_ _0843_ net762 _0988_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__mux2_1
X_4214_ clknet_leaf_51_clk _0050_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_4145_ net670 net17 _2032_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_87_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4076_ _0880_ net895 _1997_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__mux2_1
X_3027_ _1066_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__clkbuf_4
X_3929_ _1918_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2260_ _0846_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_2191_ _0799_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_48_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4832_ clknet_leaf_11_clk _0668_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4763_ clknet_leaf_11_clk _0599_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_3714_ net845 net39 _1795_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__mux2_1
X_4694_ clknet_leaf_5_clk _0530_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3645_ _1763_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3576_ _1725_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__clkbuf_1
X_2527_ _0896_ net875 _1016_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__mux2_1
X_2458_ _0825_ net968 _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold38 _0191_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 instance_0.rdata\[56\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 _0163_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 instance_0.rdata\[0\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2389_ _0936_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
X_4128_ net857 net8 _2025_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__mux2_1
X_4059_ _1989_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_82_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold508 instance_1.mem\[3\]\[17\] VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3430_ _1645_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__clkbuf_1
Xhold519 instance_0.mem\[0\]\[50\] VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dlygate4sd3_1
X_3361_ _0963_ net717 _1606_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__mux2_1
X_2312_ net62 VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_29_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3292_ _0890_ net579 _1569_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__mux2_1
X_2243_ net375 _0834_ _0826_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__mux2_1
X_2174_ _0790_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_38_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4815_ clknet_leaf_26_clk _0651_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4746_ clknet_leaf_19_clk _0582_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4677_ clknet_leaf_17_clk _0513_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_3628_ _1754_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3559_ _1716_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2930_ net227 _1319_ _1330_ _1332_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__o22a_1
X_4600_ clknet_leaf_26_clk _0436_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_2861_ net279 _1211_ _1277_ _1279_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__o22a_1
XFILLER_0_53_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2792_ instance_0.mem\[3\]\[52\] _1177_ _1190_ instance_0.mem\[2\]\[52\] VGND VGND
+ VPWR VPWR _1228_ sky130_fd_sc_hd__a22o_1
X_4531_ clknet_leaf_21_clk _0367_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[37\] sky130_fd_sc_hd__dfxtp_1
Xhold316 instance_1.mem\[3\]\[35\] VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__dlygate4sd3_1
Xhold305 instance_1.mem\[2\]\[29\] VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__dlygate4sd3_1
X_4462_ clknet_leaf_21_clk _0298_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[40\] sky130_fd_sc_hd__dfxtp_1
Xhold349 instance_0.mem\[3\]\[60\] VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold327 instance_0.mem\[3\]\[66\] VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__dlygate4sd3_1
Xhold338 instance_1.mem\[1\]\[37\] VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__dlygate4sd3_1
X_3413_ _1636_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__clkbuf_1
X_4393_ clknet_leaf_15_clk net308 VGND VGND VPWR VPWR instance_1.rdata\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_90_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3344_ _1598_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3275_ _1560_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__clkbuf_1
X_2226_ net32 VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2157_ _0781_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
X_2088_ instance_0.rdata\[18\] instance_1.rdata\[18\] _0743_ VGND VGND VPWR VPWR _0744_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4729_ clknet_leaf_33_clk _0565_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3060_ net390 _1428_ _1344_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3962_ _0928_ net779 _1933_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2913_ _1107_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3893_ net394 net49 _1896_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_61_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2844_ _1029_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_60_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4514_ clknet_leaf_36_clk _0350_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_2775_ _1055_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__buf_2
Xhold102 _0219_ VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 instance_0.rdata\[41\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 _0167_ VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 instance_0.rdata\[37\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
Xhold157 instance_1.rdata\[45\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold146 _0117_ VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
Xhold168 _0207_ VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
X_4445_ clknet_leaf_36_clk _0281_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold179 instance_0.rdata\[71\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
X_4376_ clknet_leaf_32_clk net346 VGND VGND VPWR VPWR instance_1.rdata\[26\] sky130_fd_sc_hd__dfxtp_1
X_3327_ _1589_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3258_ _1551_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__clkbuf_1
X_2209_ _0808_ _0810_ _0720_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__and3b_1
X_3189_ _0950_ net416 _1512_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold680 instance_0.mem\[2\]\[51\] VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__dlygate4sd3_1
Xhold691 instance_0.mem\[2\]\[20\] VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_404 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2560_ _1046_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__buf_2
XFILLER_0_49_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2491_ _0999_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
X_4230_ clknet_leaf_35_clk _0066_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4161_ _2044_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__clkbuf_1
X_3112_ instance_1.mem\[1\]\[61\] _1448_ _1094_ instance_1.mem\[3\]\[61\] VGND VGND
+ VPWR VPWR _1467_ sky130_fd_sc_hd__a22o_1
X_4092_ _2007_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__clkbuf_1
X_3043_ instance_1.mem\[3\]\[42\] _1389_ _1408_ instance_1.mem\[2\]\[42\] VGND VGND
+ VPWR VPWR _1417_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_66_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3945_ _0911_ net742 _1926_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3876_ net641 net40 _1889_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2827_ _1253_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2758_ _1036_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__buf_2
X_2689_ instance_0.mem\[3\]\[27\] _1119_ _1127_ instance_0.mem\[2\]\[27\] VGND VGND
+ VPWR VPWR _1150_ sky130_fd_sc_hd__a22o_1
X_4428_ clknet_leaf_48_clk _0264_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4359_ clknet_leaf_43_clk net210 VGND VGND VPWR VPWR instance_1.rdata\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3730_ net681 net46 _1809_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3661_ net783 _0945_ _1766_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__mux2_1
X_3592_ net601 _0873_ _1729_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__mux2_1
X_2612_ _1046_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__buf_4
X_2543_ _1030_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_10_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2474_ _0990_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
X_4213_ clknet_leaf_47_clk _0049_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_79_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4144_ _2035_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_87_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4075_ _1998_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__clkbuf_1
X_3026_ instance_1.mem\[3\]\[38\] _1389_ _1372_ instance_1.mem\[2\]\[38\] VGND VGND
+ VPWR VPWR _1404_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3928_ net475 net66 _1917_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__mux2_1
X_3859_ net686 net32 _1874_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2190_ instance_0.rdata\[65\] instance_1.rdata\[65\] _0793_ VGND VGND VPWR VPWR _0799_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4831_ clknet_leaf_11_clk _0667_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4762_ clknet_leaf_10_clk _0598_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_4693_ clknet_leaf_2_clk _0529_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_3713_ _1800_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__clkbuf_1
X_3644_ net577 _0928_ _1759_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3575_ net580 _0856_ _1722_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__mux2_1
X_2526_ _1018_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
X_2457_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__buf_2
Xhold17 instance_0.rdata\[9\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 _0170_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_3_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2388_ _0934_ net893 _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__mux2_1
Xhold39 instance_1.rdata\[40\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd3_1
X_4127_ _2026_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__clkbuf_1
X_4058_ _0862_ net608 _1983_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__mux2_1
X_3009_ net249 _1388_ _1390_ _1391_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_82_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_54_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_54_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_52_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold509 instance_0.mem\[0\]\[43\] VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__dlygate4sd3_1
X_3360_ _1607_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__clkbuf_1
X_2311_ _0881_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
X_3291_ _1533_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__buf_2
X_2242_ net38 VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2173_ instance_0.rdata\[57\] instance_1.rdata\[57\] _0786_ VGND VGND VPWR VPWR _0790_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4814_ clknet_leaf_23_clk _0650_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4745_ clknet_leaf_25_clk _0581_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_83_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4676_ clknet_leaf_18_clk _0512_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3627_ net432 _0911_ _1752_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3558_ net573 _0838_ _1715_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__mux2_1
X_2509_ _0980_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__buf_2
X_3489_ net469 _0932_ _1672_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_36_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_36_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_27_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_27_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_57_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2860_ instance_0.mem\[1\]\[69\] _1260_ _1278_ instance_0.mem\[3\]\[69\] _1266_ VGND
+ VGND VPWR VPWR _1279_ sky130_fd_sc_hd__a221o_1
XFILLER_0_57_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2791_ _1073_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__buf_2
XFILLER_0_80_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4530_ clknet_leaf_19_clk _0366_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4461_ clknet_leaf_17_clk _0297_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[39\] sky130_fd_sc_hd__dfxtp_1
Xhold306 instance_1.rdata\[0\] VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold317 instance_0.mem\[3\]\[25\] VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__dlygate4sd3_1
Xhold328 instance_1.mem\[3\]\[45\] VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__dlygate4sd3_1
Xhold339 instance_0.mem\[3\]\[0\] VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__dlygate4sd3_1
X_3412_ _0851_ net910 _1635_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__mux2_1
X_4392_ clknet_leaf_17_clk net302 VGND VGND VPWR VPWR instance_1.rdata\[42\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_90_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3343_ _0945_ net705 _1592_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__mux2_1
X_3274_ _0873_ net812 _1555_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__mux2_1
X_2225_ _0822_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
X_2156_ instance_0.rdata\[49\] instance_1.rdata\[49\] _0779_ VGND VGND VPWR VPWR _0781_
+ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_18_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2087_ _0721_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__buf_2
XFILLER_0_63_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2989_ net508 _1376_ _1344_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4728_ clknet_leaf_38_clk _0564_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_4659_ clknet_leaf_33_clk _0495_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_55_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_66_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3961_ _1936_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2912_ _1293_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__buf_2
XFILLER_0_85_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3892_ _1898_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_75_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2843_ instance_0.mem\[0\]\[66\] _1189_ _1262_ instance_0.mem\[3\]\[66\] VGND VGND
+ VPWR VPWR _1265_ sky130_fd_sc_hd__a22o_1
X_2774_ instance_0.mem\[2\]\[48\] _1100_ _1050_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4513_ clknet_leaf_33_clk _0349_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold103 instance_1.rdata\[57\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 instance_0.rdata\[52\] VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold114 _0151_ VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
Xhold158 _0231_ VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold136 _0155_ VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 instance_1.rdata\[3\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_7_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
X_4444_ clknet_leaf_34_clk _0280_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
Xhold169 instance_1.rdata\[29\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
X_4375_ clknet_leaf_32_clk net322 VGND VGND VPWR VPWR instance_1.rdata\[25\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_84_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3326_ _0928_ net628 _1585_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3257_ _0856_ net521 _1548_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__mux2_1
X_2208_ _0809_ net1 VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__and2b_1
X_3188_ _1513_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
X_2139_ _0771_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold681 instance_0.mem\[1\]\[29\] VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold670 instance_0.mem\[0\]\[32\] VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dlygate4sd3_1
Xhold692 instance_1.mem\[3\]\[54\] VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2490_ _0858_ net559 _0995_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4160_ net687 net24 _2039_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3111_ _1466_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
X_4091_ _0896_ net597 _2004_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__mux2_1
X_3042_ net365 _1407_ _1415_ _1416_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_66_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3944_ _1927_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3875_ _1881_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__buf_2
X_2826_ net533 _1252_ _1024_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2757_ instance_0.mem\[1\]\[44\] _1146_ _1200_ instance_0.mem\[3\]\[44\] VGND VGND
+ VPWR VPWR _1201_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2688_ _1025_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__buf_2
X_4427_ clknet_leaf_52_clk _0263_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4358_ clknet_leaf_38_clk net344 VGND VGND VPWR VPWR instance_1.rdata\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3309_ _0911_ net527 _1578_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__mux2_1
X_4289_ clknet_leaf_43_clk net172 VGND VGND VPWR VPWR instance_0.rdata\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_37_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3660_ _1771_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__clkbuf_1
X_2611_ instance_0.mem\[0\]\[10\] _1060_ _1088_ instance_0.mem\[2\]\[10\] VGND VGND
+ VPWR VPWR _1089_ sky130_fd_sc_hd__a22o_1
X_3591_ _1733_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2542_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__buf_2
X_2473_ _0841_ net657 _0988_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__mux2_1
X_4212_ clknet_leaf_48_clk _0048_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_79_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4143_ net679 net16 _2032_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__mux2_1
X_4074_ _0877_ net625 _1997_ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_87_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3025_ net333 _1388_ _1400_ _1403_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_34_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3927_ _1881_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__buf_2
X_3858_ _1879_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__clkbuf_1
X_2809_ instance_0.mem\[3\]\[57\] _1177_ _1190_ instance_0.mem\[2\]\[57\] VGND VGND
+ VPWR VPWR _1240_ sky130_fd_sc_hd__a22o_1
X_3789_ _1842_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4830_ clknet_leaf_8_clk _0666_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4761_ clknet_leaf_8_clk _0597_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4692_ clknet_leaf_2_clk _0528_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_3712_ net883 net38 _1795_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__mux2_1
X_3643_ _1762_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3574_ _1724_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__clkbuf_1
X_2525_ _0894_ net746 _1016_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2456_ _0907_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__buf_2
Xhold18 _0123_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 instance_0.rdata\[26\] VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4126_ net510 net7 _2025_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__mux2_1
X_2387_ _0908_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__buf_2
XFILLER_0_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4057_ _1988_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__clkbuf_1
X_3008_ instance_1.mem\[1\]\[33\] _1385_ _1350_ instance_1.mem\[0\]\[33\] _1386_ VGND
+ VGND VPWR VPWR _1391_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_82_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3290_ _1568_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__clkbuf_1
X_2310_ net953 _0880_ _0878_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__mux2_1
X_2241_ _0833_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2172_ _0789_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_1
XFILLER_0_87_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4813_ clknet_leaf_23_clk _0649_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4744_ clknet_leaf_27_clk _0580_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4675_ clknet_leaf_21_clk _0511_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_3626_ _1753_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__clkbuf_1
X_3557_ _1707_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__buf_2
X_2508_ _1008_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
X_3488_ _1677_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__clkbuf_1
X_2439_ _0970_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4109_ _2016_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2790_ _1223_ _1224_ _1226_ _1211_ net153 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__o32a_1
XFILLER_0_53_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4460_ clknet_leaf_18_clk _0296_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[38\] sky130_fd_sc_hd__dfxtp_1
Xhold307 instance_1.rdata\[67\] VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold329 instance_0.mem\[1\]\[43\] VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__dlygate4sd3_1
X_4391_ clknet_leaf_19_clk net366 VGND VGND VPWR VPWR instance_1.rdata\[41\] sky130_fd_sc_hd__dfxtp_1
Xhold318 instance_1.rdata\[60\] VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__dlygate4sd3_1
X_3411_ _1620_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_21_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3342_ _1597_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3273_ _1559_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__clkbuf_1
X_2224_ net943 _0821_ _0813_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__mux2_1
X_2155_ _0780_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_1
X_2086_ _0742_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2988_ instance_1.mem\[0\]\[28\] instance_1.mem\[1\]\[28\] instance_1.mem\[2\]\[28\]
+ instance_1.mem\[3\]\[28\] _1335_ _1375_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__mux4_1
XFILLER_0_8_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4727_ clknet_leaf_41_clk _0563_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4658_ clknet_leaf_22_clk _0494_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xhold830 instance_0.mem\[2\]\[36\] VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__dlygate4sd3_1
X_3609_ _1707_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__buf_2
X_4589_ clknet_leaf_22_clk _0425_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3960_ _0926_ net780 _1933_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2911_ net343 _1294_ _1314_ _1318_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_61_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3891_ net791 net47 _1896_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2842_ net161 _1248_ _1263_ _1264_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__o22a_1
X_2773_ net181 _1193_ _1212_ _1213_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__o22a_1
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4512_ clknet_leaf_38_clk _0348_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold115 instance_0.rdata\[36\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
Xhold104 _0243_ VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
Xhold126 _0166_ VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
Xhold159 instance_1.rdata\[43\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold148 _0189_ VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
Xhold137 instance_0.rdata\[4\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
X_4443_ clknet_leaf_34_clk _0279_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4374_ clknet_leaf_31_clk net234 VGND VGND VPWR VPWR instance_1.rdata\[24\] sky130_fd_sc_hd__dfxtp_1
X_3325_ _1588_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__clkbuf_1
X_3256_ _1550_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_69_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2207_ net2 VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__buf_1
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3187_ _0947_ net907 _1512_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__mux2_1
X_2138_ instance_0.rdata\[41\] instance_1.rdata\[41\] _0765_ VGND VGND VPWR VPWR _0771_
+ sky130_fd_sc_hd__mux2_1
X_2069_ _0733_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold671 instance_1.mem\[0\]\[47\] VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__dlygate4sd3_1
Xhold660 instance_0.mem\[1\]\[63\] VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__dlygate4sd3_1
Xhold693 instance_0.mem\[2\]\[42\] VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlygate4sd3_1
Xhold682 instance_0.mem\[0\]\[2\] VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_27_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3110_ net466 _1465_ _1446_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4090_ _2006_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__clkbuf_1
X_3041_ instance_1.mem\[1\]\[41\] _1385_ _1405_ instance_1.mem\[0\]\[41\] _1410_ VGND
+ VGND VPWR VPWR _1416_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_66_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3943_ _0904_ net460 _1926_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3874_ _1888_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__clkbuf_1
X_2825_ instance_0.mem\[0\]\[61\] instance_0.mem\[1\]\[61\] instance_0.mem\[2\]\[61\]
+ instance_0.mem\[3\]\[61\] _1251_ _1205_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__mux4_1
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_14_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2756_ _1093_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2687_ net177 _1131_ _1147_ _1148_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__o22a_1
XFILLER_0_69_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4426_ clknet_leaf_52_clk _0262_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4357_ clknet_leaf_51_clk net358 VGND VGND VPWR VPWR instance_1.rdata\[7\] sky130_fd_sc_hd__dfxtp_1
X_3308_ _1579_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__clkbuf_1
X_4288_ clknet_leaf_46_clk net184 VGND VGND VPWR VPWR instance_0.rdata\[10\] sky130_fd_sc_hd__dfxtp_1
X_3239_ _1533_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_37_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold490 instance_0.mem\[3\]\[19\] VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3590_ net551 _0871_ _1729_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__mux2_1
X_2610_ _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__clkbuf_4
X_2541_ _0720_ _0808_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__or2b_2
XFILLER_0_50_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2472_ _0989_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
X_4211_ clknet_leaf_51_clk _0047_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_79_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4142_ _2034_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__clkbuf_1
X_4073_ _1968_ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__buf_2
X_3024_ instance_1.mem\[0\]\[37\] _1401_ _1396_ instance_1.mem\[2\]\[37\] _1402_ VGND
+ VGND VPWR VPWR _1403_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_34_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3926_ _1916_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3857_ net594 net31 _1874_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3788_ net607 net26 _1839_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__mux2_1
X_2808_ net175 _1227_ _1237_ _1239_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__o22a_1
X_2739_ net535 _1187_ _1111_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4409_ clknet_leaf_1_clk net354 VGND VGND VPWR VPWR instance_1.rdata\[59\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_6_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4760_ clknet_leaf_11_clk _0596_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3711_ _1799_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__clkbuf_1
X_4691_ clknet_leaf_11_clk _0527_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_3642_ net558 _0926_ _1759_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3573_ net722 _0854_ _1722_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2524_ _1017_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2455_ _0979_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2386_ net7 VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__dlymetal6s2s_1
Xhold19 instance_0.rdata\[58\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
X_4125_ _0891_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_3_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4056_ _0860_ net787 _1983_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__mux2_1
X_3007_ instance_1.mem\[3\]\[33\] _1389_ _1372_ instance_1.mem\[2\]\[33\] VGND VGND
+ VPWR VPWR _1390_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_19_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3909_ _1907_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_2_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2240_ net547 _0832_ _0826_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__mux2_1
X_2171_ instance_0.rdata\[56\] instance_1.rdata\[56\] _0786_ VGND VGND VPWR VPWR _0789_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4812_ clknet_leaf_25_clk _0648_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_16_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4743_ clknet_leaf_27_clk _0579_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4674_ clknet_leaf_19_clk _0510_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_3625_ net598 _0904_ _1752_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__mux2_1
X_3556_ _1714_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2507_ _0875_ net710 _1002_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__mux2_1
X_3487_ net420 _0930_ _1672_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__mux2_1
X_2438_ _0969_ net934 _0961_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__mux2_1
X_2369_ _0921_ net721 _0922_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__mux2_1
X_4108_ net509 net48 _2011_ VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__mux2_1
X_4039_ _0843_ net837 _1976_ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_50_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold308 instance_1.mem\[3\]\[71\] VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3410_ _1634_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__clkbuf_1
Xhold319 instance_1.mem\[2\]\[4\] VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__dlygate4sd3_1
X_4390_ clknet_leaf_21_clk net188 VGND VGND VPWR VPWR instance_1.rdata\[40\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3341_ _0943_ net870 _1592_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__mux2_1
X_3272_ _0871_ net665 _1555_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__mux2_1
X_2223_ net31 VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2154_ instance_0.rdata\[48\] instance_1.rdata\[48\] _0779_ VGND VGND VPWR VPWR _0780_
+ sky130_fd_sc_hd__mux2_1
X_2085_ instance_0.rdata\[17\] instance_1.rdata\[17\] _0736_ VGND VGND VPWR VPWR _0742_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2987_ _1034_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__clkbuf_4
X_4726_ clknet_leaf_38_clk _0562_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4657_ clknet_leaf_33_clk _0493_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
Xhold820 instance_0.mem\[0\]\[36\] VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__dlygate4sd3_1
X_3608_ _1742_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold831 instance_0.mem\[3\]\[69\] VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__dlygate4sd3_1
X_4588_ clknet_leaf_34_clk _0424_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_3539_ net537 _0821_ _1700_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_55_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2910_ instance_1.mem\[1\]\[8\] _1315_ _1316_ instance_1.mem\[2\]\[8\] _1317_ VGND
+ VGND VPWR VPWR _1318_ sky130_fd_sc_hd__a221o_1
X_3890_ _1897_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__clkbuf_1
X_2841_ instance_0.mem\[0\]\[65\] _1202_ _1231_ instance_0.mem\[2\]\[65\] _1242_ VGND
+ VGND VPWR VPWR _1264_ sky130_fd_sc_hd__a221o_1
X_2772_ instance_0.mem\[1\]\[47\] _1173_ _1108_ instance_0.mem\[3\]\[47\] _1203_ VGND
+ VGND VPWR VPWR _1213_ sky130_fd_sc_hd__a221o_1
X_4511_ clknet_leaf_40_clk _0347_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold116 _0150_ VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold105 instance_0.rdata\[22\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
X_4442_ clknet_leaf_35_clk _0278_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xhold149 instance_1.rdata\[35\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 instance_0.rdata\[62\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 _0118_ VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4373_ clknet_leaf_36_clk net362 VGND VGND VPWR VPWR instance_1.rdata\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3324_ _0926_ net858 _1585_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__mux2_1
X_3255_ _0854_ net913 _1548_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__mux2_1
X_2206_ net76 VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__buf_1
X_3186_ _1490_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__buf_2
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2137_ _0770_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__buf_1
X_2068_ instance_0.rdata\[9\] instance_1.rdata\[9\] _0729_ VGND VGND VPWR VPWR _0733_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4709_ clknet_leaf_56_clk _0545_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[71\] sky130_fd_sc_hd__dfxtp_1
Xhold672 instance_0.mem\[0\]\[41\] VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__dlygate4sd3_1
Xhold661 instance_1.mem\[1\]\[30\] VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__dlygate4sd3_1
Xhold650 instance_0.mem\[2\]\[52\] VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dlygate4sd3_1
Xhold694 instance_0.mem\[0\]\[30\] VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlygate4sd3_1
Xhold683 instance_0.mem\[2\]\[66\] VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3040_ instance_1.mem\[3\]\[41\] _1389_ _1408_ instance_1.mem\[2\]\[41\] VGND VGND
+ VPWR VPWR _1415_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_66_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3942_ _1925_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3873_ net877 net39 _1882_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2824_ _1033_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__buf_4
XFILLER_0_14_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2755_ _1199_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2686_ instance_0.mem\[0\]\[26\] _1144_ _1135_ instance_0.mem\[2\]\[26\] _1129_ VGND
+ VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a221o_1
X_4425_ clknet_leaf_47_clk _0261_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_4356_ clknet_leaf_48_clk _0192_ VGND VGND VPWR VPWR instance_1.rdata\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3307_ _0904_ net772 _1578_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__mux2_1
X_4287_ clknet_leaf_43_clk net166 VGND VGND VPWR VPWR instance_0.rdata\[9\] sky130_fd_sc_hd__dfxtp_1
X_3238_ _1540_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
X_3169_ _0930_ net700 _1498_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold480 instance_0.mem\[2\]\[9\] VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_8_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold491 instance_0.mem\[1\]\[38\] VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_35_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2540_ _1027_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__buf_2
X_2471_ _0838_ net773 _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4210_ clknet_leaf_52_clk _0046_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4141_ net647 net14 _2032_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__mux2_1
X_4072_ _1996_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__clkbuf_1
X_3023_ _1165_ _1070_ instance_1.mem\[3\]\[37\] VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__and3_1
XFILLER_0_25_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3925_ net633 net65 _1910_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3856_ _1878_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3787_ _1841_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__clkbuf_1
X_2807_ instance_0.mem\[1\]\[56\] _1215_ _1169_ instance_0.mem\[0\]\[56\] _1238_ VGND
+ VGND VPWR VPWR _1239_ sky130_fd_sc_hd__a221o_1
X_2738_ instance_0.mem\[0\]\[39\] instance_0.mem\[1\]\[39\] instance_0.mem\[2\]\[39\]
+ instance_0.mem\[3\]\[39\] _1186_ _1071_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4408_ clknet_leaf_5_clk net174 VGND VGND VPWR VPWR instance_1.rdata\[58\] sky130_fd_sc_hd__dfxtp_1
X_2669_ _1039_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_6_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4339_ clknet_leaf_1_clk _0175_ VGND VGND VPWR VPWR instance_0.rdata\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_57_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_57_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_48_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3710_ net853 net36 _1795_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4690_ clknet_leaf_9_clk _0526_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_3641_ _1761_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3572_ _1723_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2523_ _0890_ net668 _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2454_ _0823_ net575 _0973_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__mux2_1
X_2385_ _0933_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
X_4124_ _2024_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_3_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 address[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_78_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_48_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_48_clk sky130_fd_sc_hd__clkbuf_8
X_4055_ _1987_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__clkbuf_1
X_3006_ _1107_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_19_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3908_ net604 net56 _1903_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3839_ _1869_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_39_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_39_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_69_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2170_ _0788_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4811_ clknet_leaf_30_clk _0647_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_16_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4742_ clknet_leaf_23_clk _0578_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4673_ clknet_leaf_25_clk _0509_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3624_ _1751_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3555_ net790 _0836_ _1708_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3486_ _1676_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__clkbuf_1
X_2506_ _1007_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
X_2437_ net24 VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2368_ _0908_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__buf_2
X_4107_ _2015_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__clkbuf_1
X_2299_ net57 VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4038_ _1978_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_50_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold309 instance_1.mem\[2\]\[20\] VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__dlygate4sd3_1
X_3340_ _1596_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3271_ _1558_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkbuf_1
X_2222_ _0820_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2153_ _0764_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__buf_2
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2084_ _0741_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2986_ net299 _1366_ _1373_ _1374_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__o22a_1
X_4725_ clknet_leaf_42_clk _0561_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_4656_ clknet_leaf_37_clk _0492_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_3607_ net480 _0888_ _1736_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__mux2_1
Xinput70 wdata[6] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__buf_1
Xhold810 instance_0.mem\[0\]\[17\] VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__dlygate4sd3_1
X_4587_ clknet_leaf_33_clk _0423_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
Xhold821 instance_0.mem\[2\]\[37\] VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__dlygate4sd3_1
X_3538_ _1704_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold832 instance_0.mem\[2\]\[70\] VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__dlygate4sd3_1
X_3469_ _1667_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2840_ instance_0.mem\[1\]\[65\] _1218_ _1262_ instance_0.mem\[3\]\[65\] VGND VGND
+ VPWR VPWR _1263_ sky130_fd_sc_hd__a22o_1
XFILLER_0_57_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2771_ instance_0.mem\[0\]\[47\] _1189_ _1190_ instance_0.mem\[2\]\[47\] VGND VGND
+ VPWR VPWR _1212_ sky130_fd_sc_hd__a22o_1
X_4510_ clknet_leaf_40_clk _0346_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold117 instance_1.rdata\[2\] VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_44_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold106 _0136_ VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
X_4441_ clknet_leaf_32_clk _0277_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold128 _0176_ VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
Xhold139 instance_0.rdata\[40\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
X_4372_ clknet_leaf_34_clk net204 VGND VGND VPWR VPWR instance_1.rdata\[22\] sky130_fd_sc_hd__dfxtp_1
X_3323_ _1587_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3254_ _1549_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__clkbuf_1
X_2205_ net27 VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__dlymetal6s2s_1
X_3185_ _1511_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_53_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2136_ instance_0.rdata\[40\] instance_1.rdata\[40\] _0765_ VGND VGND VPWR VPWR _0770_
+ sky130_fd_sc_hd__mux2_1
X_2067_ _0732_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_1
XFILLER_0_44_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2969_ instance_1.rdata\[23\] _1347_ _1360_ _1361_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_60_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4708_ clknet_leaf_54_clk _0544_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[70\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_62_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4639_ clknet_leaf_49_clk _0475_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold640 instance_0.mem\[2\]\[3\] VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__dlygate4sd3_1
Xhold662 instance_0.mem\[3\]\[15\] VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dlygate4sd3_1
Xhold651 instance_1.mem\[3\]\[52\] VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dlygate4sd3_1
Xhold695 instance_0.mem\[0\]\[29\] VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__dlygate4sd3_1
Xhold673 instance_0.mem\[0\]\[65\] VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlygate4sd3_1
Xhold684 instance_0.mem\[0\]\[5\] VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_71_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_80_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3941_ _1924_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__buf_2
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3872_ _1887_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2823_ net213 _1248_ _1249_ _1250_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__o22a_1
X_2754_ net403 _1198_ _1111_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2685_ instance_0.mem\[1\]\[26\] _1146_ _1113_ instance_0.mem\[3\]\[26\] VGND VGND
+ VPWR VPWR _1147_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4424_ clknet_leaf_52_clk _0260_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4355_ clknet_leaf_37_clk net186 VGND VGND VPWR VPWR instance_1.rdata\[5\] sky130_fd_sc_hd__dfxtp_1
X_3306_ _1577_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__buf_2
X_4286_ clknet_leaf_51_clk net268 VGND VGND VPWR VPWR instance_0.rdata\[8\] sky130_fd_sc_hd__dfxtp_1
X_3237_ _0836_ net919 _1534_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__mux2_1
X_3168_ _1502_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
X_2119_ _0760_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_37_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3099_ instance_1.mem\[3\]\[57\] _1090_ _1437_ instance_1.mem\[2\]\[57\] VGND VGND
+ VPWR VPWR _1458_ sky130_fd_sc_hd__a22o_1
XFILLER_0_49_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold481 instance_0.mem\[2\]\[39\] VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__dlygate4sd3_1
Xhold470 instance_0.mem\[2\]\[6\] VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__dlygate4sd3_1
Xhold492 instance_1.mem\[2\]\[54\] VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2470_ _0980_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4140_ _2033_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__clkbuf_1
X_4071_ _0875_ net949 _1990_ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__mux2_1
X_3022_ _1036_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_78_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3924_ _1915_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3855_ net632 net30 _1874_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3786_ net854 net15 _1839_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__mux2_1
X_2806_ _1165_ _1161_ instance_0.mem\[3\]\[56\] VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__and3_1
X_2737_ _1041_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__buf_4
X_2668_ instance_0.mem\[1\]\[22\] _1078_ _1113_ instance_0.mem\[3\]\[22\] VGND VGND
+ VPWR VPWR _1134_ sky130_fd_sc_hd__a22o_1
X_4407_ clknet_leaf_3_clk net252 VGND VGND VPWR VPWR instance_1.rdata\[57\] sky130_fd_sc_hd__dfxtp_1
X_2599_ _1039_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__buf_2
X_4338_ clknet_leaf_0_clk net214 VGND VGND VPWR VPWR instance_0.rdata\[60\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_6_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4269_ clknet_leaf_58_clk _0105_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_76_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3640_ net693 _0924_ _1759_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__mux2_1
X_3571_ net846 _0851_ _1722_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__mux2_1
X_2522_ _0980_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__buf_2
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2453_ _0978_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
X_2384_ _0932_ net802 _0922_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__mux2_1
X_4123_ net546 net6 _2018_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput2 address[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__dlymetal6s2s_1
X_4054_ _0858_ net816 _1983_ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__mux2_1
X_3005_ _1346_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__buf_2
XFILLER_0_74_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3907_ _1906_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3838_ net465 net21 _1867_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3769_ net692 net66 _1830_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4810_ clknet_leaf_28_clk _0646_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_16_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4741_ clknet_leaf_23_clk _0577_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4672_ clknet_leaf_26_clk _0508_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_3623_ _1750_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__buf_2
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3554_ _1713_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__clkbuf_1
X_3485_ net448 _0928_ _1672_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__mux2_1
X_2505_ _0873_ net586 _1002_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__mux2_1
X_2436_ _0968_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
X_2367_ net70 VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4106_ net731 net37 _2011_ VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__mux2_1
X_2298_ _0872_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
X_4037_ _0841_ net785 _1976_ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_50_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3270_ _0869_ net504 _1555_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_90_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2221_ net775 _0819_ _0813_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__mux2_1
X_2152_ _0778_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_1
X_2083_ instance_0.rdata\[16\] instance_1.rdata\[16\] _0736_ VGND VGND VPWR VPWR _0741_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2985_ instance_1.mem\[1\]\[27\] _1349_ _1278_ instance_1.mem\[3\]\[27\] _1364_ VGND
+ VGND VPWR VPWR _1374_ sky130_fd_sc_hd__a221o_1
X_4724_ clknet_leaf_42_clk _0560_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_83_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4655_ clknet_leaf_41_clk _0491_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xinput60 wdata[60] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_1
Xinput71 wdata[70] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_1
X_3606_ _1741_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__clkbuf_1
Xhold800 instance_0.mem\[0\]\[57\] VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__dlygate4sd3_1
Xhold811 instance_0.mem\[3\]\[51\] VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__dlygate4sd3_1
X_4586_ clknet_leaf_22_clk _0422_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_3537_ net549 _0819_ _1700_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold822 instance_1.mem\[2\]\[59\] VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3468_ net384 _0911_ _1665_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3399_ _0838_ net841 _1628_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__mux2_1
X_2419_ _0956_ net706 _0948_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_55_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2770_ _1208_ _1209_ _1210_ _1211_ net149 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__o32a_1
XFILLER_0_80_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold107 instance_1.rdata\[17\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
X_4440_ clknet_leaf_34_clk _0276_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold118 _0188_ VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
Xhold129 instance_1.rdata\[55\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4371_ clknet_leaf_33_clk net316 VGND VGND VPWR VPWR instance_1.rdata\[21\] sky130_fd_sc_hd__dfxtp_1
X_3322_ _0924_ net784 _1585_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3253_ _0851_ net955 _1548_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2204_ _0806_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_1
X_3184_ _0945_ net806 _1505_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__mux2_1
X_2135_ _0769_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
X_2066_ instance_0.rdata\[8\] instance_1.rdata\[8\] _0729_ VGND VGND VPWR VPWR _0732_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2968_ net361 _1053_ _1298_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_60_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4707_ clknet_leaf_55_clk _0543_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_2899_ instance_1.mem\[0\]\[6\] instance_1.mem\[1\]\[6\] instance_1.mem\[2\]\[6\]
+ instance_1.mem\[3\]\[6\] _1251_ _1290_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__mux4_1
X_4638_ clknet_leaf_56_clk _0474_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold630 instance_0.mem\[1\]\[5\] VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dlygate4sd3_1
Xhold641 instance_0.mem\[1\]\[44\] VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlygate4sd3_1
X_4569_ clknet_leaf_50_clk _0405_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xhold652 instance_0.mem\[1\]\[68\] VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__dlygate4sd3_1
Xhold663 instance_0.mem\[2\]\[44\] VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dlygate4sd3_1
Xhold674 instance_1.mem\[1\]\[7\] VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlygate4sd3_1
Xhold685 instance_0.mem\[1\]\[62\] VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlygate4sd3_1
Xhold696 instance_0.mem\[0\]\[4\] VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_35_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3940_ _0905_ _0906_ _0809_ net3 VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_74_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3871_ net750 net38 _1882_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__mux2_1
X_2822_ instance_0.mem\[0\]\[60\] _1202_ _1231_ instance_0.mem\[2\]\[60\] _1242_ VGND
+ VGND VPWR VPWR _1250_ sky130_fd_sc_hd__a221o_1
X_2753_ instance_0.mem\[0\]\[43\] instance_0.mem\[1\]\[43\] instance_0.mem\[2\]\[43\]
+ instance_0.mem\[3\]\[43\] _1186_ _1071_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__mux4_1
XFILLER_0_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2684_ _1077_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__clkbuf_4
X_4423_ clknet_leaf_48_clk _0259_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_4354_ clknet_leaf_50_clk net238 VGND VGND VPWR VPWR instance_1.rdata\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3305_ _1576_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__buf_2
X_4285_ clknet_leaf_47_clk net190 VGND VGND VPWR VPWR instance_0.rdata\[7\] sky130_fd_sc_hd__dfxtp_1
X_3236_ _1539_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
X_3167_ _0928_ net804 _1498_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__mux2_1
X_3098_ net155 _1454_ _1455_ _1457_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__o22a_1
X_2118_ instance_0.rdata\[32\] instance_1.rdata\[32\] _0757_ VGND VGND VPWR VPWR _0760_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2049_ instance_0.rdata\[0\] instance_1.rdata\[0\] _0722_ VGND VGND VPWR VPWR _0723_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold471 instance_0.mem\[2\]\[12\] VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__dlygate4sd3_1
Xhold460 instance_1.mem\[0\]\[53\] VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__dlygate4sd3_1
Xhold493 instance_0.mem\[3\]\[42\] VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold482 instance_1.mem\[0\]\[24\] VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4070_ _1995_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__clkbuf_1
X_3021_ instance_1.mem\[1\]\[37\] _1028_ _1298_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__a21o_1
XFILLER_0_78_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3923_ net920 net64 _1910_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3854_ _1877_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2805_ instance_0.mem\[2\]\[56\] _1088_ _1050_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3785_ _1840_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2736_ net159 _1171_ _1184_ _1185_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__o22a_1
XFILLER_0_26_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2667_ net363 _1131_ _1132_ _1133_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__o22a_1
X_4406_ clknet_leaf_6_clk net156 VGND VGND VPWR VPWR instance_1.rdata\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2598_ instance_0.mem\[1\]\[7\] _1078_ _1048_ instance_0.mem\[3\]\[7\] VGND VGND
+ VPWR VPWR _1079_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4337_ clknet_leaf_1_clk _0173_ VGND VGND VPWR VPWR instance_0.rdata\[59\] sky130_fd_sc_hd__dfxtp_1
X_4268_ clknet_leaf_0_clk _0104_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_3219_ _0819_ net873 _1526_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__mux2_1
X_4199_ clknet_leaf_59_clk _0035_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold290 instance_1.mem\[3\]\[15\] VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_86_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3570_ _1707_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__buf_2
X_2521_ _1015_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2452_ _0821_ net902 _0973_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2383_ net6 VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__buf_1
X_4122_ _2023_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__clkbuf_1
X_4053_ _1986_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__clkbuf_1
Xinput3 address[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_2
X_3004_ net335 _1366_ _1384_ _1387_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__o22a_1
XFILLER_0_59_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3906_ net381 net55 _1903_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_342 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3837_ _1868_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__clkbuf_1
X_3768_ _1794_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__buf_2
X_2719_ _1055_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__buf_2
X_3699_ _1792_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_259 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4740_ clknet_leaf_25_clk _0576_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4671_ clknet_leaf_26_clk _0507_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3622_ _0808_ _1038_ _1285_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__and3b_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3553_ net512 _0834_ _1708_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__mux2_1
X_2504_ _1006_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
X_3484_ _1675_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__clkbuf_1
X_2435_ _0967_ net954 _0961_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__mux2_1
X_2366_ _0920_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
X_4105_ _2014_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2297_ net516 _0871_ _0865_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__mux2_1
X_4036_ _1977_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4869_ clknet_leaf_42_clk _0705_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_6_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2220_ net30 VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_84_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2151_ instance_0.rdata\[47\] instance_1.rdata\[47\] _0772_ VGND VGND VPWR VPWR _0778_
+ sky130_fd_sc_hd__mux2_1
X_2082_ _0740_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2984_ instance_1.mem\[0\]\[27\] _1371_ _1372_ instance_1.mem\[2\]\[27\] VGND VGND
+ VPWR VPWR _1373_ sky130_fd_sc_hd__a22o_1
X_4723_ clknet_leaf_41_clk _0559_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4654_ clknet_leaf_40_clk _0490_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold812 instance_0.mem\[1\]\[69\] VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput72 wdata[71] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__buf_1
XFILLER_0_24_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput61 wdata[61] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_1
X_3605_ net621 _0886_ _1736_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__mux2_1
Xhold801 instance_1.mem\[0\]\[59\] VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlygate4sd3_1
X_4585_ clknet_leaf_33_clk _0421_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
Xinput50 wdata[51] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
Xhold823 instance_0.mem\[2\]\[64\] VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__dlygate4sd3_1
X_3536_ _1703_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__clkbuf_1
X_3467_ _1666_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__clkbuf_1
X_3398_ _1620_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__clkbuf_4
X_2418_ net18 VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2349_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__buf_2
X_4019_ _1967_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold108 _0203_ VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
Xhold119 instance_0.rdata\[8\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
X_4370_ clknet_leaf_22_clk net340 VGND VGND VPWR VPWR instance_1.rdata\[20\] sky130_fd_sc_hd__dfxtp_1
X_3321_ _1586_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3252_ _1533_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__clkbuf_4
X_2203_ instance_0.rdata\[71\] instance_1.rdata\[71\] _0800_ VGND VGND VPWR VPWR _0806_
+ sky130_fd_sc_hd__mux2_1
X_3183_ _1510_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
X_2134_ instance_0.rdata\[39\] instance_1.rdata\[39\] _0765_ VGND VGND VPWR VPWR _0769_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2065_ _0731_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_1
XFILLER_0_48_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2967_ instance_1.mem\[1\]\[23\] _1027_ _1099_ instance_1.mem\[2\]\[23\] _1359_ VGND
+ VGND VPWR VPWR _1360_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_60_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4706_ clknet_leaf_54_clk _0542_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_2898_ net185 _1294_ _1306_ _1308_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__o22a_1
X_4637_ clknet_leaf_56_clk _0473_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold620 instance_1.mem\[2\]\[2\] VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__dlygate4sd3_1
Xhold653 instance_0.mem\[2\]\[29\] VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__dlygate4sd3_1
Xhold642 instance_1.mem\[3\]\[41\] VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__dlygate4sd3_1
Xhold631 instance_1.mem\[0\]\[9\] VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlygate4sd3_1
X_4568_ clknet_leaf_53_clk _0404_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xhold697 instance_1.mem\[2\]\[41\] VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__dlygate4sd3_1
Xhold664 instance_0.mem\[1\]\[58\] VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dlygate4sd3_1
X_4499_ clknet_leaf_52_clk _0335_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold675 instance_0.mem\[1\]\[15\] VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlygate4sd3_1
Xhold686 instance_0.mem\[3\]\[52\] VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__dlygate4sd3_1
X_3519_ _1694_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_20_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_89_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3870_ _1886_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__clkbuf_1
X_2821_ instance_0.mem\[1\]\[60\] _1218_ _1200_ instance_0.mem\[3\]\[60\] VGND VGND
+ VPWR VPWR _1249_ sky130_fd_sc_hd__a22o_1
XFILLER_0_45_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2752_ net199 _1193_ _1196_ _1197_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__o22a_1
Xclkbuf_leaf_11_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
X_4422_ clknet_leaf_49_clk _0258_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2683_ net281 _1131_ _1143_ _1145_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__o22a_1
X_4353_ clknet_leaf_50_clk net296 VGND VGND VPWR VPWR instance_1.rdata\[3\] sky130_fd_sc_hd__dfxtp_1
X_4284_ clknet_leaf_46_clk _0120_ VGND VGND VPWR VPWR instance_0.rdata\[6\] sky130_fd_sc_hd__dfxtp_1
X_3304_ _1285_ _0905_ _1038_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__or3b_1
X_3235_ _0834_ net865 _1534_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__mux2_1
X_3166_ _1501_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
X_3097_ instance_1.mem\[1\]\[56\] _1225_ _1432_ instance_1.mem\[3\]\[56\] _1456_ VGND
+ VGND VPWR VPWR _1457_ sky130_fd_sc_hd__a221o_1
X_2117_ _0759_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_1
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2048_ _0721_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__buf_2
XFILLER_0_64_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3999_ _0965_ net684 _1954_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold472 instance_0.mem\[2\]\[30\] VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__dlygate4sd3_1
Xhold450 instance_1.mem\[2\]\[0\] VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__dlygate4sd3_1
Xhold461 instance_1.mem\[3\]\[24\] VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__dlygate4sd3_1
Xhold494 instance_0.mem\[3\]\[29\] VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__dlygate4sd3_1
Xhold483 instance_1.mem\[0\]\[56\] VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_67_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3020_ net359 _1388_ _1398_ _1399_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__o22a_1
Xclkbuf_leaf_0_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_34_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3922_ _1914_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3853_ net437 net29 _1874_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2804_ _1236_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
X_3784_ net487 net4 _1839_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__mux2_1
X_2735_ instance_0.mem\[0\]\[38\] _1144_ _1182_ instance_0.mem\[2\]\[38\] _1179_ VGND
+ VGND VPWR VPWR _1185_ sky130_fd_sc_hd__a221o_1
XFILLER_0_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2666_ instance_0.mem\[0\]\[21\] _1067_ _1080_ instance_0.mem\[2\]\[21\] _1129_ VGND
+ VGND VPWR VPWR _1133_ sky130_fd_sc_hd__a221o_1
X_4405_ clknet_leaf_3_clk net278 VGND VGND VPWR VPWR instance_1.rdata\[55\] sky130_fd_sc_hd__dfxtp_1
X_4336_ clknet_leaf_5_clk net168 VGND VGND VPWR VPWR instance_0.rdata\[58\] sky130_fd_sc_hd__dfxtp_1
X_2597_ _1077_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__clkbuf_4
X_4267_ clknet_leaf_0_clk _0103_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4198_ clknet_leaf_4_clk _0034_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_3218_ _1529_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
X_3149_ _1492_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_59_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_68_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold280 instance_1.mem\[0\]\[28\] VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold291 instance_1.mem\[2\]\[23\] VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_76_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2520_ _0888_ net821 _1009_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__mux2_1
X_2451_ _0977_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
X_2382_ _0931_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
X_4121_ net436 net5 _2018_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__mux2_1
X_4052_ _0856_ net756 _1983_ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__mux2_1
Xinput4 wdata[0] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
X_3003_ instance_1.mem\[1\]\[32\] _1385_ _1278_ instance_1.mem\[3\]\[32\] _1386_ VGND
+ VGND VPWR VPWR _1387_ sky130_fd_sc_hd__a221o_1
XFILLER_0_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3905_ _1905_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3836_ net409 net20 _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3767_ _1829_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2718_ instance_0.mem\[3\]\[34\] _1119_ _1127_ instance_0.mem\[2\]\[34\] VGND VGND
+ VPWR VPWR _1172_ sky130_fd_sc_hd__a22o_1
X_3698_ net542 net31 _1787_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2649_ instance_0.mem\[3\]\[17\] _1119_ _1088_ instance_0.mem\[2\]\[17\] VGND VGND
+ VPWR VPWR _1120_ sky130_fd_sc_hd__a22o_1
X_4319_ clknet_leaf_19_clk net284 VGND VGND VPWR VPWR instance_0.rdata\[41\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4670_ clknet_leaf_23_clk _0506_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3621_ _1749_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__clkbuf_1
X_3552_ _1712_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2503_ _0871_ net948 _1002_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__mux2_1
X_3483_ net400 _0926_ _1672_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__mux2_1
X_2434_ net23 VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2365_ _0919_ net832 _0909_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__mux2_1
X_4104_ net514 net26 _2011_ VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2296_ net56 VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4035_ _0838_ net682 _1976_ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_20 _1278_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4868_ clknet_leaf_42_clk _0704_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_34_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3819_ _1858_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__clkbuf_1
X_4799_ clknet_leaf_41_clk _0635_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2150_ _0777_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_1
X_2081_ instance_0.rdata\[15\] instance_1.rdata\[15\] _0736_ VGND VGND VPWR VPWR _0740_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2983_ _1087_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__clkbuf_4
X_4722_ clknet_leaf_39_clk _0558_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput40 wdata[42] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_1
X_4653_ clknet_leaf_42_clk _0489_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
Xhold802 instance_0.mem\[0\]\[7\] VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__dlygate4sd3_1
X_3604_ _1740_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__clkbuf_1
Xinput62 wdata[62] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_1
Xinput73 wdata[7] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__buf_1
X_4584_ clknet_leaf_37_clk _0420_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xinput51 wdata[52] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_1
Xhold813 instance_1.mem\[0\]\[41\] VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold824 instance_0.mem\[1\]\[4\] VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__dlygate4sd3_1
X_3535_ net518 _0817_ _1700_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3466_ net443 _0904_ _1665_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__mux2_1
X_2417_ _0955_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_3397_ _1627_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2348_ _0907_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__buf_2
X_2279_ _0859_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_4018_ _0823_ net874 _1961_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_488 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold109 instance_0.rdata\[48\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
X_3320_ _0921_ net618 _1585_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_13_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3251_ _1547_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__clkbuf_1
X_2202_ _0805_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_1
X_3182_ _0943_ net925 _1505_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__mux2_1
X_2133_ _0768_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2064_ instance_0.rdata\[7\] instance_1.rdata\[7\] _0729_ VGND VGND VPWR VPWR _0731_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_22_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2966_ _1069_ _1070_ instance_1.mem\[3\]\[23\] VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__and3_1
X_4705_ clknet_leaf_57_clk _0541_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[67\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2897_ instance_1.mem\[0\]\[5\] _1270_ _1274_ instance_1.mem\[2\]\[5\] _1307_ VGND
+ VGND VPWR VPWR _1308_ sky130_fd_sc_hd__a221o_1
XFILLER_0_44_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4636_ clknet_leaf_7_clk _0472_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[70\] sky130_fd_sc_hd__dfxtp_1
Xhold610 instance_0.rdata\[55\] VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dlygate4sd3_1
Xhold621 instance_0.mem\[0\]\[19\] VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__dlygate4sd3_1
X_4567_ clknet_leaf_49_clk _0403_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold654 instance_0.mem\[0\]\[11\] VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_31_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold632 instance_1.mem\[0\]\[8\] VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlygate4sd3_1
Xhold643 instance_0.mem\[3\]\[49\] VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlygate4sd3_1
Xhold676 instance_0.mem\[1\]\[3\] VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__dlygate4sd3_1
X_4498_ clknet_leaf_52_clk _0334_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xhold665 instance_0.mem\[1\]\[25\] VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dlygate4sd3_1
Xhold687 instance_0.mem\[2\]\[32\] VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dlygate4sd3_1
X_3518_ net609 _0960_ _1693_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__mux2_1
X_3449_ _1655_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__clkbuf_1
Xhold698 instance_1.mem\[3\]\[48\] VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_68_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2820_ _1073_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__buf_2
XFILLER_0_38_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2751_ instance_0.mem\[1\]\[42\] _1173_ _1182_ instance_0.mem\[2\]\[42\] _1179_ VGND
+ VGND VPWR VPWR _1197_ sky130_fd_sc_hd__a221o_1
XFILLER_0_81_472 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2682_ instance_0.mem\[0\]\[25\] _1144_ _1135_ instance_0.mem\[2\]\[25\] _1129_ VGND
+ VGND VPWR VPWR _1145_ sky130_fd_sc_hd__a221o_1
X_4421_ clknet_leaf_55_clk _0257_ VGND VGND VPWR VPWR instance_1.rdata\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4352_ clknet_leaf_52_clk net266 VGND VGND VPWR VPWR instance_1.rdata\[2\] sky130_fd_sc_hd__dfxtp_1
X_3303_ _1575_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__clkbuf_1
X_4283_ clknet_leaf_52_clk net230 VGND VGND VPWR VPWR instance_0.rdata\[5\] sky130_fd_sc_hd__dfxtp_1
X_3234_ _1538_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
X_3165_ _0926_ net951 _1498_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__mux2_1
X_3096_ _1297_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__buf_2
X_2116_ instance_0.rdata\[31\] instance_1.rdata\[31\] _0757_ VGND VGND VPWR VPWR _0759_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2047_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__buf_2
XFILLER_0_49_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3998_ _1956_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2949_ _1287_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__buf_2
X_4619_ clknet_leaf_10_clk _0455_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[53\] sky130_fd_sc_hd__dfxtp_1
Xhold451 instance_1.mem\[1\]\[26\] VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__dlygate4sd3_1
Xhold462 instance_1.rdata\[15\] VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__dlygate4sd3_1
Xhold440 instance_0.mem\[3\]\[59\] VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__dlygate4sd3_1
Xhold484 instance_0.mem\[3\]\[33\] VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__dlygate4sd3_1
Xhold495 instance_0.mem\[3\]\[38\] VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__dlygate4sd3_1
Xhold473 instance_1.mem\[3\]\[64\] VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_71_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3921_ net753 net63 _1910_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3852_ _1876_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2803_ net758 _1235_ _1024_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3783_ _1838_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_42_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2734_ instance_0.mem\[1\]\[38\] _1146_ _1153_ instance_0.mem\[3\]\[38\] VGND VGND
+ VPWR VPWR _1184_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2665_ instance_0.mem\[1\]\[21\] _1078_ _1113_ instance_0.mem\[3\]\[21\] VGND VGND
+ VPWR VPWR _1132_ sky130_fd_sc_hd__a22o_1
X_4404_ clknet_leaf_3_clk net246 VGND VGND VPWR VPWR instance_1.rdata\[54\] sky130_fd_sc_hd__dfxtp_1
X_2596_ _1076_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4335_ clknet_leaf_4_clk net194 VGND VGND VPWR VPWR instance_0.rdata\[57\] sky130_fd_sc_hd__dfxtp_1
X_4266_ clknet_leaf_0_clk _0102_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_4197_ clknet_leaf_57_clk _0033_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_3217_ _0817_ net886 _1526_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3148_ _0904_ net885 _1491_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3079_ instance_1.mem\[1\]\[52\] _1362_ _1394_ instance_1.mem\[3\]\[52\] VGND VGND
+ VPWR VPWR _1443_ sky130_fd_sc_hd__a22o_1
XFILLER_0_64_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold270 instance_1.mem\[2\]\[12\] VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__dlygate4sd3_1
Xhold292 instance_1.mem\[1\]\[38\] VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__dlygate4sd3_1
Xhold281 instance_0.mem\[3\]\[16\] VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_76_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2450_ _0819_ net792 _0973_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2381_ _0930_ net793 _0922_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__mux2_1
X_4120_ _2022_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__clkbuf_1
X_4051_ _1985_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__clkbuf_1
Xinput5 wdata[10] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
XFILLER_0_36_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3002_ _1297_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_47_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3904_ net563 net54 _1903_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3835_ _1838_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__buf_2
XFILLER_0_14_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3766_ net483 net65 _1823_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__mux2_1
X_2717_ _1073_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__buf_2
X_3697_ _1791_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2648_ _1093_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__clkbuf_4
X_2579_ instance_0.mem\[1\]\[4\] _1028_ _1053_ instance_0.mem\[0\]\[4\] VGND VGND
+ VPWR VPWR _1063_ sky130_fd_sc_hd__a22o_1
X_4318_ clknet_leaf_21_clk net288 VGND VGND VPWR VPWR instance_0.rdata\[40\] sky130_fd_sc_hd__dfxtp_1
X_4249_ clknet_leaf_15_clk _0085_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3620_ net456 _0902_ _1743_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__mux2_1
X_3551_ net664 _0832_ _1708_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2502_ _1005_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3482_ _1674_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__clkbuf_1
X_2433_ _0966_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2364_ net59 VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4103_ _2013_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_87_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2295_ _0870_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
X_4034_ _1968_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__buf_2
XFILLER_0_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_21 _1278_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4867_ clknet_leaf_41_clk _0703_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_10 net2 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3818_ net429 net11 _1853_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_50_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4798_ clknet_leaf_40_clk _0634_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3749_ net473 net56 _1816_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_58_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2080_ _0739_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2982_ _1059_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_68_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4721_ clknet_leaf_47_clk _0557_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4652_ clknet_leaf_42_clk _0488_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xinput30 wdata[33] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_1
X_3603_ net523 _0884_ _1736_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput41 wdata[43] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
Xinput63 wdata[63] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_1
Xhold803 instance_0.mem\[1\]\[8\] VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__dlygate4sd3_1
X_4583_ clknet_leaf_41_clk _0419_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xinput52 wdata[53] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_1
Xhold825 instance_1.mem\[0\]\[13\] VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__dlygate4sd3_1
Xinput74 wdata[8] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_1
Xhold814 instance_0.mem\[1\]\[37\] VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__dlygate4sd3_1
X_3534_ _1702_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3465_ _1664_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__buf_2
X_2416_ _0954_ net748 _0948_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3396_ _0836_ net661 _1621_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__mux2_1
X_2347_ net3 _0905_ _0906_ _0809_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__or4_1
XFILLER_0_79_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2278_ net447 _0858_ _0852_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__mux2_1
X_4017_ _1966_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_55_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3250_ _0849_ net956 _1541_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__mux2_1
X_2201_ instance_0.rdata\[70\] instance_1.rdata\[70\] _0800_ VGND VGND VPWR VPWR _0805_
+ sky130_fd_sc_hd__mux2_1
X_3181_ _1509_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
X_2132_ instance_0.rdata\[38\] instance_1.rdata\[38\] _0765_ VGND VGND VPWR VPWR _0768_
+ sky130_fd_sc_hd__mux2_1
X_2063_ _0730_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4704_ clknet_leaf_54_clk _0540_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_312 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2965_ net203 _1347_ _1357_ _1358_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_60_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2896_ _1165_ _1161_ instance_1.mem\[3\]\[5\] VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__and3_1
XFILLER_0_60_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4635_ clknet_leaf_56_clk _0471_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4566_ clknet_leaf_56_clk _0402_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold611 instance_1.mem\[0\]\[64\] VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlygate4sd3_1
Xhold600 instance_0.mem\[0\]\[21\] VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dlygate4sd3_1
Xhold644 instance_0.mem\[0\]\[33\] VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold622 instance_0.mem\[1\]\[52\] VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dlygate4sd3_1
Xhold633 instance_0.mem\[1\]\[51\] VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlygate4sd3_1
X_3517_ _1664_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__buf_2
Xhold677 instance_0.mem\[1\]\[27\] VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dlygate4sd3_1
Xhold666 instance_1.mem\[1\]\[35\] VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlygate4sd3_1
X_4497_ clknet_leaf_50_clk _0333_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xhold688 instance_0.mem\[0\]\[1\] VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__dlygate4sd3_1
Xhold655 instance_1.mem\[0\]\[37\] VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlygate4sd3_1
X_3448_ _0888_ net716 _1649_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__mux2_1
Xhold699 instance_0.mem\[0\]\[40\] VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dlygate4sd3_1
X_3379_ _1617_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_68_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2750_ instance_0.mem\[0\]\[42\] _1189_ _1153_ instance_0.mem\[3\]\[42\] VGND VGND
+ VPWR VPWR _1196_ sky130_fd_sc_hd__a22o_1
XFILLER_0_81_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2681_ _1066_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__clkbuf_4
X_4420_ clknet_leaf_53_clk net338 VGND VGND VPWR VPWR instance_1.rdata\[70\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4351_ clknet_leaf_48_clk _0187_ VGND VGND VPWR VPWR instance_1.rdata\[1\] sky130_fd_sc_hd__dfxtp_1
X_3302_ _0902_ net923 _1569_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__mux2_1
X_4282_ clknet_leaf_52_clk net286 VGND VGND VPWR VPWR instance_0.rdata\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3233_ _0832_ net739 _1534_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__mux2_1
X_3164_ _1500_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
X_2115_ _0758_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
X_3095_ instance_1.mem\[0\]\[56\] _1096_ _1437_ instance_1.mem\[2\]\[56\] VGND VGND
+ VPWR VPWR _1455_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_65_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2046_ net3 VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__dlymetal6s2s_1
X_3997_ _0963_ net807 _1954_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2948_ _1345_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2879_ _1287_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__buf_2
X_4618_ clknet_leaf_9_clk _0454_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[52\] sky130_fd_sc_hd__dfxtp_1
Xhold441 instance_0.mem\[0\]\[9\] VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__dlygate4sd3_1
Xhold463 instance_0.mem\[3\]\[70\] VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__dlygate4sd3_1
Xhold452 instance_0.rdata\[14\] VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__dlygate4sd3_1
X_4549_ clknet_leaf_2_clk _0385_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[55\] sky130_fd_sc_hd__dfxtp_1
Xhold430 instance_1.rdata\[51\] VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__dlygate4sd3_1
Xhold485 instance_0.mem\[3\]\[65\] VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__dlygate4sd3_1
Xhold496 instance_0.mem\[3\]\[62\] VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__dlygate4sd3_1
Xhold474 instance_1.mem\[2\]\[11\] VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3920_ _1913_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3851_ net399 net28 _1874_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__mux2_1
X_2802_ instance_0.mem\[0\]\[55\] instance_0.mem\[1\]\[55\] instance_0.mem\[2\]\[55\]
+ instance_0.mem\[3\]\[55\] _1186_ _1205_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__mux4_1
X_3782_ _1837_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_42_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2733_ net261 _1171_ _1181_ _1183_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__o22a_1
XFILLER_0_81_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2664_ _1025_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__buf_2
XFILLER_0_41_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4403_ clknet_leaf_10_clk _0239_ VGND VGND VPWR VPWR instance_1.rdata\[53\] sky130_fd_sc_hd__dfxtp_1
X_2595_ _0810_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__buf_2
X_4334_ clknet_leaf_7_clk net176 VGND VGND VPWR VPWR instance_0.rdata\[56\] sky130_fd_sc_hd__dfxtp_1
X_4265_ clknet_leaf_1_clk _0101_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4196_ clknet_leaf_59_clk _0032_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_3216_ _1528_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
X_3147_ _1490_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__buf_2
XFILLER_0_82_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3078_ _1442_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold271 instance_0.mem\[2\]\[63\] VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__dlygate4sd3_1
Xhold260 instance_1.mem\[1\]\[48\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__dlygate4sd3_1
Xhold282 instance_1.mem\[2\]\[47\] VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__dlygate4sd3_1
Xhold293 instance_1.mem\[3\]\[66\] VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_76_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2380_ net5 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4050_ _0854_ net623 _1983_ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__mux2_1
Xinput6 wdata[11] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
X_3001_ _1076_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__buf_2
XFILLER_0_36_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4883_ clknet_leaf_30_clk _0719_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_3903_ _1904_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__clkbuf_1
X_3834_ _1866_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__clkbuf_1
X_3765_ _1828_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3696_ net584 net30 _1787_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__mux2_1
X_2716_ net371 _1149_ _1168_ _1170_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__o22a_1
X_2647_ net323 _1104_ _1116_ _1118_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__o22a_1
X_2578_ net293 _1026_ _1061_ _1062_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__o22a_1
X_4317_ clknet_leaf_17_clk _0153_ VGND VGND VPWR VPWR instance_0.rdata\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4248_ clknet_leaf_17_clk _0084_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_4179_ clknet_leaf_13_clk _0015_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[45\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_81_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_20_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3550_ _1711_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2501_ _0869_ net474 _1002_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3481_ net714 _0924_ _1672_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2432_ _0965_ net976 _0961_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__mux2_1
X_2363_ _0918_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4102_ net388 net15 _2011_ VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__mux2_1
X_4033_ _1975_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__clkbuf_1
X_2294_ net490 _0869_ _0865_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_22 _1278_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4866_ clknet_leaf_39_clk _0702_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_11 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4797_ clknet_leaf_42_clk _0633_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3817_ _1857_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_50_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3748_ _1819_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3679_ net520 _0963_ _1780_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__mux2_1
Xoutput140 net140 VGND VGND VPWR VPWR rdata[67] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_392 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_50_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_50_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_21_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2981_ net345 _1366_ _1369_ _1370_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__o22a_1
XFILLER_0_33_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4720_ clknet_leaf_48_clk _0556_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_41_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_41_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4651_ clknet_leaf_41_clk _0487_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xinput31 wdata[34] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
X_3602_ _1739_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__clkbuf_1
Xinput20 wdata[24] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
Xinput42 wdata[44] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_1
Xinput64 wdata[64] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_1
Xinput53 wdata[54] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_1
X_4582_ clknet_leaf_38_clk _0418_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput75 wdata[9] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_1
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold815 instance_0.mem\[1\]\[54\] VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__dlygate4sd3_1
Xhold826 instance_0.mem\[2\]\[53\] VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__dlygate4sd3_1
Xhold804 instance_0.mem\[0\]\[52\] VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__dlygate4sd3_1
X_3533_ net485 _0815_ _1700_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__mux2_1
X_3464_ _1663_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__buf_2
X_2415_ net17 VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_58_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3395_ _1626_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__clkbuf_1
X_2346_ net1 VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__buf_1
X_2277_ net50 VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4016_ _0821_ net882 _1961_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_32_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_32_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4849_ clknet_leaf_57_clk _0685_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_23_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_53_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2200_ _0804_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3180_ _0941_ net823 _1505_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__mux2_1
X_2131_ _0767_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_1
X_2062_ instance_0.rdata\[6\] instance_1.rdata\[6\] _0729_ VGND VGND VPWR VPWR _0730_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2964_ instance_1.mem\[0\]\[22\] _1339_ _1316_ instance_1.mem\[2\]\[22\] _1331_ VGND
+ VGND VPWR VPWR _1358_ sky130_fd_sc_hd__a221o_1
Xclkbuf_leaf_14_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
X_4703_ clknet_leaf_59_clk _0539_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2895_ instance_1.mem\[1\]\[5\] _1028_ _1298_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4634_ clknet_leaf_7_clk _0470_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_4565_ clknet_leaf_55_clk _0401_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[71\] sky130_fd_sc_hd__dfxtp_1
Xhold601 instance_0.mem\[3\]\[10\] VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold612 instance_1.mem\[3\]\[19\] VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlygate4sd3_1
Xhold645 instance_0.mem\[0\]\[10\] VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlygate4sd3_1
X_3516_ _1692_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__clkbuf_1
Xhold623 instance_1.mem\[2\]\[24\] VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dlygate4sd3_1
Xhold634 instance_0.mem\[1\]\[31\] VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dlygate4sd3_1
Xhold667 instance_0.mem\[3\]\[36\] VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlygate4sd3_1
Xhold656 instance_0.mem\[1\]\[9\] VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold678 instance_0.mem\[2\]\[4\] VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__dlygate4sd3_1
X_4496_ clknet_leaf_52_clk _0332_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xhold689 instance_1.mem\[0\]\[44\] VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3447_ _1654_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__clkbuf_1
X_3378_ _0819_ net655 _1613_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__mux2_1
X_2329_ net67 VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_68_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2680_ instance_0.mem\[1\]\[25\] _1078_ _1113_ instance_0.mem\[3\]\[25\] VGND VGND
+ VPWR VPWR _1143_ sky130_fd_sc_hd__a22o_1
XFILLER_0_81_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4350_ clknet_leaf_49_clk _0186_ VGND VGND VPWR VPWR instance_1.rdata\[0\] sky130_fd_sc_hd__dfxtp_1
X_3301_ _1574_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__clkbuf_1
X_4281_ clknet_leaf_51_clk net294 VGND VGND VPWR VPWR instance_0.rdata\[3\] sky130_fd_sc_hd__dfxtp_1
X_3232_ _1537_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_3_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
X_3163_ _0924_ net817 _1498_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__mux2_1
X_2114_ instance_0.rdata\[30\] instance_1.rdata\[30\] _0757_ VGND VGND VPWR VPWR _0758_
+ sky130_fd_sc_hd__mux2_1
X_3094_ _1346_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_65_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3996_ _1955_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2947_ net744 _1343_ _1344_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2878_ _1292_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4617_ clknet_leaf_10_clk _0453_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[51\] sky130_fd_sc_hd__dfxtp_1
Xhold420 instance_1.mem\[2\]\[22\] VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__dlygate4sd3_1
Xhold431 instance_0.mem\[1\]\[66\] VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__dlygate4sd3_1
Xhold453 instance_1.mem\[3\]\[58\] VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__dlygate4sd3_1
X_4548_ clknet_leaf_2_clk _0384_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[54\] sky130_fd_sc_hd__dfxtp_1
Xhold442 instance_0.mem\[1\]\[46\] VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__dlygate4sd3_1
Xhold464 instance_1.mem\[3\]\[29\] VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__dlygate4sd3_1
Xhold486 instance_1.mem\[0\]\[27\] VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__dlygate4sd3_1
X_4479_ clknet_leaf_4_clk _0315_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[57\] sky130_fd_sc_hd__dfxtp_1
Xhold475 instance_1.mem\[0\]\[49\] VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__dlygate4sd3_1
Xhold497 instance_1.mem\[0\]\[70\] VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3850_ _1875_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__clkbuf_1
X_3781_ _1285_ _0905_ _1033_ _0809_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__and4bb_1
X_2801_ net313 _1227_ _1233_ _1234_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_42_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2732_ instance_0.mem\[0\]\[37\] _1144_ _1182_ instance_0.mem\[2\]\[37\] _1179_ VGND
+ VGND VPWR VPWR _1183_ sky130_fd_sc_hd__a221o_1
XFILLER_0_81_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2663_ net195 _1104_ _1128_ _1130_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__o22a_1
X_2594_ _1025_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__buf_2
XFILLER_0_22_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4402_ clknet_leaf_9_clk net192 VGND VGND VPWR VPWR instance_1.rdata\[52\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4333_ clknet_leaf_2_clk _0169_ VGND VGND VPWR VPWR instance_0.rdata\[55\] sky130_fd_sc_hd__dfxtp_1
X_4264_ clknet_leaf_5_clk _0100_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3215_ _0815_ net782 _1526_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__mux2_1
X_4195_ clknet_leaf_1_clk _0031_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3146_ _1489_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__buf_2
XFILLER_0_77_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3077_ net578 _1441_ _1344_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_28_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3979_ _0945_ net683 _1940_ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold250 instance_1.mem\[2\]\[63\] VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__dlygate4sd3_1
Xhold261 instance_0.mem\[3\]\[24\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__dlygate4sd3_1
Xhold272 instance_1.mem\[3\]\[10\] VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__dlygate4sd3_1
Xhold283 instance_0.mem\[3\]\[8\] VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__dlygate4sd3_1
Xhold294 instance_0.mem\[1\]\[59\] VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput7 wdata[12] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_0_36_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3000_ instance_1.mem\[0\]\[32\] _1371_ _1372_ instance_1.mem\[2\]\[32\] VGND VGND
+ VPWR VPWR _1384_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_47_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4882_ clknet_leaf_29_clk _0718_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_3902_ net554 net53 _1903_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3833_ net729 net19 _1860_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3764_ net732 net64 _1823_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__mux2_1
X_2715_ instance_0.mem\[1\]\[33\] _1140_ _1169_ instance_0.mem\[0\]\[33\] _1151_ VGND
+ VGND VPWR VPWR _1170_ sky130_fd_sc_hd__a221o_1
XFILLER_0_42_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3695_ _1790_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__clkbuf_1
X_2646_ instance_0.mem\[1\]\[16\] _1106_ _1080_ instance_0.mem\[2\]\[16\] _1117_ VGND
+ VGND VPWR VPWR _1118_ sky130_fd_sc_hd__a221o_1
X_2577_ instance_0.mem\[1\]\[3\] _1056_ _1040_ instance_0.mem\[2\]\[3\] _1057_ VGND
+ VGND VPWR VPWR _1062_ sky130_fd_sc_hd__a221o_1
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4316_ clknet_leaf_18_clk net160 VGND VGND VPWR VPWR instance_0.rdata\[38\] sky130_fd_sc_hd__dfxtp_1
X_4247_ clknet_leaf_19_clk _0083_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_4178_ clknet_leaf_13_clk _0014_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[44\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3129_ net351 _1293_ _1477_ _1478_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_81_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3480_ _1673_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__clkbuf_1
X_2500_ _1004_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
X_2431_ net22 VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2362_ _0917_ net844 _0909_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__mux2_1
X_4101_ _2012_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__clkbuf_1
X_2293_ net55 VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_47_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4032_ _0836_ net961 _1969_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4865_ clknet_leaf_47_clk _0701_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_12 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_23 _1241_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4796_ clknet_3_5__leaf_clk _0632_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[14\]
+ sky130_fd_sc_hd__dfxtp_1
X_3816_ net810 net10 _1853_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__mux2_1
X_3747_ net543 net55 _1816_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__mux2_1
X_3678_ _1781_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput141 net141 VGND VGND VPWR VPWR rdata[68] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput130 net130 VGND VGND VPWR VPWR rdata[58] sky130_fd_sc_hd__clkbuf_4
X_2629_ _1025_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_58_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2980_ instance_1.mem\[1\]\[26\] _1349_ _1350_ instance_1.mem\[0\]\[26\] _1364_ VGND
+ VGND VPWR VPWR _1370_ sky130_fd_sc_hd__a221o_1
XFILLER_0_8_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4650_ clknet_leaf_39_clk _0486_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3601_ net433 _0882_ _1736_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__mux2_1
Xinput10 wdata[15] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
Xinput21 wdata[25] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
Xinput32 wdata[35] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
Xinput43 wdata[45] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4581_ clknet_leaf_42_clk _0417_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
Xinput54 wdata[55] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
X_3532_ _1701_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__clkbuf_1
Xinput65 wdata[65] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_1
Xhold827 instance_0.mem\[0\]\[70\] VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__dlygate4sd3_1
Xhold805 instance_1.mem\[1\]\[61\] VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__dlygate4sd3_1
Xhold816 instance_1.mem\[3\]\[61\] VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__dlygate4sd3_1
Xinput76 wr_n VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_1
X_3463_ _0808_ _1046_ _1285_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__and3b_1
X_2414_ _0953_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
X_3394_ _0834_ net935 _1621_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__mux2_1
X_2345_ net76 VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__buf_1
XFILLER_0_74_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2276_ _0857_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
X_4015_ _1965_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4848_ clknet_leaf_5_clk _0684_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4779_ clknet_leaf_55_clk _0615_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2130_ instance_0.rdata\[37\] instance_1.rdata\[37\] _0765_ VGND VGND VPWR VPWR _0767_
+ sky130_fd_sc_hd__mux2_1
X_2061_ _0721_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2963_ instance_1.mem\[1\]\[22\] _1272_ _1311_ instance_1.mem\[3\]\[22\] VGND VGND
+ VPWR VPWR _1357_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4702_ clknet_leaf_0_clk _0538_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[64\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2894_ net237 _1294_ _1304_ _1305_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__o22a_1
XFILLER_0_44_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4633_ clknet_leaf_57_clk _0469_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_4564_ clknet_leaf_55_clk _0400_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[70\] sky130_fd_sc_hd__dfxtp_1
Xhold602 instance_0.mem\[3\]\[40\] VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold624 instance_0.mem\[2\]\[0\] VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold635 instance_1.mem\[2\]\[17\] VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__dlygate4sd3_1
Xhold613 instance_1.mem\[3\]\[55\] VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dlygate4sd3_1
X_3515_ net380 _0958_ _1686_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__mux2_1
X_4495_ clknet_leaf_49_clk _0331_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold679 instance_0.mem\[2\]\[10\] VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__dlygate4sd3_1
Xhold657 instance_0.mem\[3\]\[18\] VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dlygate4sd3_1
Xhold668 instance_1.mem\[0\]\[51\] VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__dlygate4sd3_1
Xhold646 instance_0.mem\[1\]\[24\] VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlygate4sd3_1
X_3446_ _0886_ net971 _1649_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3377_ _1616_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__clkbuf_1
X_2328_ _0893_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_68_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2259_ net570 _0845_ _0839_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3300_ _0900_ net928 _1569_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__mux2_1
X_4280_ clknet_leaf_52_clk net248 VGND VGND VPWR VPWR instance_0.rdata\[2\] sky130_fd_sc_hd__dfxtp_1
X_3231_ _0830_ net639 _1534_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__mux2_1
X_3162_ _1499_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
X_2113_ _0721_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__buf_2
X_3093_ net277 _1430_ _1452_ _1453_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_65_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3995_ _0960_ net630 _1954_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2946_ _1287_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__clkbuf_4
X_2877_ net540 _1291_ _1288_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4616_ clknet_leaf_12_clk _0452_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[50\] sky130_fd_sc_hd__dfxtp_1
Xhold410 instance_1.mem\[2\]\[8\] VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__dlygate4sd3_1
Xhold443 instance_0.mem\[1\]\[28\] VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__dlygate4sd3_1
Xhold454 instance_1.mem\[3\]\[12\] VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__dlygate4sd3_1
Xhold421 instance_1.mem\[2\]\[16\] VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__dlygate4sd3_1
X_4547_ clknet_leaf_11_clk _0383_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[53\] sky130_fd_sc_hd__dfxtp_1
Xhold432 instance_1.mem\[3\]\[50\] VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__dlygate4sd3_1
Xhold487 instance_1.mem\[3\]\[43\] VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__dlygate4sd3_1
Xhold465 instance_1.mem\[0\]\[62\] VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__dlygate4sd3_1
Xhold476 instance_0.mem\[1\]\[14\] VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__dlygate4sd3_1
X_4478_ clknet_leaf_6_clk _0314_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[56\] sky130_fd_sc_hd__dfxtp_1
Xhold498 instance_0.mem\[1\]\[61\] VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__dlygate4sd3_1
X_3429_ _0869_ net511 _1642_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_199 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3780_ _1836_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__clkbuf_1
X_2800_ instance_0.mem\[0\]\[54\] _1202_ _1231_ instance_0.mem\[2\]\[54\] _1203_ VGND
+ VGND VPWR VPWR _1234_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_42_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2731_ _1039_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_54_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4401_ clknet_leaf_8_clk _0237_ VGND VGND VPWR VPWR instance_1.rdata\[51\] sky130_fd_sc_hd__dfxtp_1
X_2662_ instance_0.mem\[1\]\[20\] _1106_ _1123_ instance_0.mem\[0\]\[20\] _1129_ VGND
+ VGND VPWR VPWR _1130_ sky130_fd_sc_hd__a221o_1
XFILLER_0_10_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2593_ _1074_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
X_4332_ clknet_leaf_10_clk net314 VGND VGND VPWR VPWR instance_0.rdata\[54\] sky130_fd_sc_hd__dfxtp_1
X_4263_ clknet_leaf_1_clk _0099_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_3214_ _1527_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
X_4194_ clknet_leaf_60_clk _0030_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3145_ _1285_ _0905_ _0810_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__or3b_1
X_3076_ instance_1.mem\[0\]\[51\] instance_1.mem\[1\]\[51\] instance_1.mem\[2\]\[51\]
+ instance_1.mem\[3\]\[51\] _1440_ _1375_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__mux4_1
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3978_ _1945_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2929_ instance_1.mem\[1\]\[13\] _1315_ _1278_ instance_1.mem\[3\]\[13\] _1331_ VGND
+ VGND VPWR VPWR _1332_ sky130_fd_sc_hd__a221o_1
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold240 instance_1.mem\[1\]\[1\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__dlygate4sd3_1
Xhold262 instance_1.mem\[1\]\[67\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__dlygate4sd3_1
Xhold251 instance_0.mem\[3\]\[31\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__dlygate4sd3_1
Xhold273 instance_1.mem\[3\]\[67\] VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__dlygate4sd3_1
Xhold284 instance_1.mem\[2\]\[1\] VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__dlygate4sd3_1
Xhold295 instance_1.mem\[3\]\[0\] VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_5_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput8 wdata[13] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_47_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4881_ clknet_leaf_30_clk _0717_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_3901_ _1881_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__buf_2
XFILLER_0_74_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3832_ _1865_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__clkbuf_1
X_3763_ _1827_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2714_ _1059_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__clkbuf_4
X_3694_ net506 net29 _1787_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2645_ _1042_ _1043_ instance_0.mem\[3\]\[16\] VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__and3_1
X_2576_ instance_0.mem\[0\]\[3\] _1060_ _1048_ instance_0.mem\[3\]\[3\] VGND VGND
+ VPWR VPWR _1061_ sky130_fd_sc_hd__a22o_1
X_4315_ clknet_leaf_21_clk net262 VGND VGND VPWR VPWR instance_0.rdata\[37\] sky130_fd_sc_hd__dfxtp_1
X_4246_ clknet_leaf_21_clk _0082_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_4177_ clknet_leaf_15_clk _0013_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3128_ instance_1.mem\[0\]\[66\] _1052_ _1450_ instance_1.mem\[2\]\[66\] _1301_ VGND
+ VGND VPWR VPWR _1478_ sky130_fd_sc_hd__a221o_1
X_3059_ instance_1.mem\[0\]\[47\] instance_1.mem\[1\]\[47\] instance_1.mem\[2\]\[47\]
+ instance_1.mem\[3\]\[47\] _1335_ _1375_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_81_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2430_ _0964_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
X_2361_ net48 VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4100_ net401 net4 _2011_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__mux2_1
X_2292_ _0868_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4031_ _1974_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_56_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_13 net102 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4864_ clknet_leaf_46_clk _0700_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_24 _1241_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3815_ _1856_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__clkbuf_1
X_4795_ clknet_leaf_41_clk _0631_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3746_ _1818_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_65_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3677_ net771 _0960_ _1780_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__mux2_1
Xoutput142 net142 VGND VGND VPWR VPWR rdata[69] sky130_fd_sc_hd__clkbuf_4
X_2628_ net157 _1075_ _1101_ _1103_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__o22a_1
Xoutput131 net131 VGND VGND VPWR VPWR rdata[59] sky130_fd_sc_hd__clkbuf_4
Xoutput120 net120 VGND VGND VPWR VPWR rdata[49] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2559_ _0906_ _0809_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4229_ clknet_leaf_36_clk _0065_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_58_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_74_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_83_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_348 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput22 wdata[26] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
X_4580_ clknet_leaf_44_clk _0416_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_3600_ _1738_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__clkbuf_1
Xinput11 wdata[16] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
Xinput33 wdata[36] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
X_3531_ net481 _0807_ _1700_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput55 wdata[56] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_1
Xinput44 wdata[46] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_1
Xhold806 instance_0.mem\[0\]\[27\] VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__dlygate4sd3_1
Xinput66 wdata[66] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_1
XFILLER_0_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold817 instance_0.mem\[0\]\[15\] VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__dlygate4sd3_1
Xhold828 instance_0.mem\[0\]\[26\] VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__dlygate4sd3_1
X_3462_ _1662_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__clkbuf_1
X_3393_ _1625_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__clkbuf_1
X_2413_ _0952_ net651 _0948_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__mux2_1
X_2344_ net4 VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2275_ net690 _0856_ _0852_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__mux2_1
X_4014_ _0819_ net698 _1961_ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__mux2_1
XFILLER_0_74_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4847_ clknet_leaf_59_clk _0683_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4778_ clknet_leaf_54_clk _0614_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3729_ _1794_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__buf_2
XFILLER_0_85_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2060_ _0728_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_1
XFILLER_0_69_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2962_ net315 _1347_ _1355_ _1356_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__o22a_1
XFILLER_0_17_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4701_ clknet_leaf_59_clk _0537_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[63\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2893_ instance_1.mem\[0\]\[4\] _1270_ _1274_ instance_1.mem\[2\]\[4\] _1302_ VGND
+ VGND VPWR VPWR _1305_ sky130_fd_sc_hd__a221o_1
X_4632_ clknet_leaf_4_clk _0468_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4563_ clknet_leaf_55_clk _0399_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_456 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold603 instance_0.mem\[2\]\[21\] VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__dlygate4sd3_1
Xhold625 instance_0.mem\[0\]\[42\] VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlygate4sd3_1
Xhold614 instance_0.mem\[0\]\[44\] VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__dlygate4sd3_1
Xhold636 instance_0.mem\[2\]\[7\] VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dlygate4sd3_1
X_4494_ clknet_leaf_49_clk _0330_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3514_ _1691_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__clkbuf_1
Xhold669 instance_0.mem\[1\]\[7\] VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__dlygate4sd3_1
X_3445_ _1653_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__clkbuf_1
Xhold658 instance_0.mem\[1\]\[17\] VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dlygate4sd3_1
Xhold647 instance_1.mem\[1\]\[16\] VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlygate4sd3_1
X_3376_ _0817_ net835 _1613_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__mux2_1
X_2327_ net522 _0890_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__mux2_1
X_2258_ net43 VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2189_ _0798_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_23_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3230_ _1536_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
X_3161_ _0921_ net649 _1498_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__mux2_1
X_2112_ _0756_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_1
X_3092_ instance_1.mem\[1\]\[55\] _1225_ _1432_ instance_1.mem\[3\]\[55\] _1433_ VGND
+ VGND VPWR VPWR _1453_ sky130_fd_sc_hd__a221o_1
XFILLER_0_55_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_73_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3994_ _1925_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__buf_2
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_315 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2945_ instance_1.mem\[0\]\[18\] instance_1.mem\[1\]\[18\] instance_1.mem\[2\]\[18\]
+ instance_1.mem\[3\]\[18\] _1335_ _1290_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__mux4_1
X_2876_ instance_1.mem\[0\]\[1\] instance_1.mem\[1\]\[1\] instance_1.mem\[2\]\[1\]
+ instance_1.mem\[3\]\[1\] _1251_ _1290_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__mux4_1
XFILLER_0_44_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4615_ clknet_leaf_12_clk _0451_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[49\] sky130_fd_sc_hd__dfxtp_1
Xhold400 instance_1.rdata\[65\] VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4546_ clknet_leaf_10_clk _0382_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[52\] sky130_fd_sc_hd__dfxtp_1
Xhold411 instance_0.mem\[0\]\[51\] VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__dlygate4sd3_1
Xhold433 instance_0.mem\[3\]\[39\] VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__dlygate4sd3_1
Xhold422 instance_1.mem\[1\]\[45\] VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__dlygate4sd3_1
Xhold444 instance_1.mem\[1\]\[54\] VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__dlygate4sd3_1
Xhold466 instance_0.mem\[0\]\[63\] VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__dlygate4sd3_1
Xhold477 instance_1.mem\[0\]\[60\] VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__dlygate4sd3_1
X_4477_ clknet_leaf_2_clk _0313_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[55\] sky130_fd_sc_hd__dfxtp_1
Xhold455 instance_1.mem\[2\]\[50\] VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__dlygate4sd3_1
Xhold488 instance_1.mem\[0\]\[12\] VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__dlygate4sd3_1
X_3428_ _1644_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__clkbuf_1
Xhold499 instance_1.mem\[1\]\[19\] VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__dlygate4sd3_1
X_3359_ _0960_ net697 _1606_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2730_ instance_0.mem\[1\]\[37\] _1146_ _1153_ instance_0.mem\[3\]\[37\] VGND VGND
+ VPWR VPWR _1181_ sky130_fd_sc_hd__a22o_1
X_2661_ _1030_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__buf_2
X_4400_ clknet_leaf_10_clk net304 VGND VGND VPWR VPWR instance_1.rdata\[50\] sky130_fd_sc_hd__dfxtp_1
X_2592_ net482 _1072_ _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4331_ clknet_leaf_10_clk net272 VGND VGND VPWR VPWR instance_0.rdata\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4262_ clknet_leaf_6_clk _0098_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_3213_ _0807_ net503 _1526_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4193_ clknet_leaf_1_clk _0029_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_3144_ _1488_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
X_3075_ _1033_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3977_ _0943_ net850 _1940_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__mux2_1
X_2928_ _1301_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__buf_2
XFILLER_0_45_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2859_ _1107_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__buf_4
XFILLER_0_32_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4529_ clknet_leaf_28_clk _0365_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[35\] sky130_fd_sc_hd__dfxtp_1
Xhold241 instance_1.mem\[2\]\[28\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__dlygate4sd3_1
Xhold230 instance_1.mem\[1\]\[46\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold252 instance_1.mem\[3\]\[8\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__dlygate4sd3_1
Xhold285 instance_1.mem\[3\]\[62\] VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__dlygate4sd3_1
Xhold274 instance_1.mem\[2\]\[67\] VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__dlygate4sd3_1
Xhold263 instance_1.mem\[1\]\[6\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__dlygate4sd3_1
Xhold296 instance_0.mem\[3\]\[21\] VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput9 wdata[14] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_47_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3900_ _1902_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__clkbuf_1
X_4880_ clknet_leaf_32_clk _0716_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3831_ net702 net18 _1860_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__mux2_1
X_3762_ net398 net63 _1823_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__mux2_1
X_2713_ instance_0.mem\[3\]\[33\] _1119_ _1127_ instance_0.mem\[2\]\[33\] VGND VGND
+ VPWR VPWR _1168_ sky130_fd_sc_hd__a22o_1
X_3693_ _1789_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2644_ instance_0.mem\[0\]\[16\] _1053_ _1031_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_10_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2575_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__clkbuf_4
X_4314_ clknet_leaf_19_clk net264 VGND VGND VPWR VPWR instance_0.rdata\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4245_ clknet_leaf_17_clk _0081_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_4176_ clknet_leaf_16_clk _0012_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[42\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3127_ instance_1.mem\[1\]\[66\] _1448_ _1094_ instance_1.mem\[3\]\[66\] VGND VGND
+ VPWR VPWR _1477_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3058_ _1427_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_81_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_129 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_53_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_53_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_16_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2360_ _0916_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
X_2291_ net675 _0867_ _0865_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4030_ _0834_ net904 _1969_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_44_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_44_clk sky130_fd_sc_hd__clkbuf_8
XANTENNA_14 net111 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4863_ clknet_leaf_47_clk _0699_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_25 _1241_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4794_ clknet_leaf_43_clk _0630_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3814_ net423 net9 _1853_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__mux2_1
X_3745_ net947 net54 _1816_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net110 VGND VGND VPWR VPWR rdata[3] sky130_fd_sc_hd__clkbuf_4
X_3676_ _1751_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__buf_2
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput121 net121 VGND VGND VPWR VPWR rdata[4] sky130_fd_sc_hd__clkbuf_4
Xoutput143 net143 VGND VGND VPWR VPWR rdata[6] sky130_fd_sc_hd__clkbuf_4
X_2627_ instance_0.mem\[1\]\[12\] _1056_ _1096_ instance_0.mem\[0\]\[12\] _1102_ VGND
+ VGND VPWR VPWR _1103_ sky130_fd_sc_hd__a221o_1
Xoutput132 net132 VGND VGND VPWR VPWR rdata[5] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2558_ net197 _1026_ _1032_ _1045_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__o22a_1
X_2489_ _0998_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
X_4228_ clknet_leaf_33_clk _0064_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_4159_ _2043_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_35_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_35_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_13_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_26_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_83_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput12 wdata[17] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
Xinput34 wdata[37] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_1
Xinput45 wdata[47] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_1
Xinput23 wdata[27] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
X_3530_ _1664_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__buf_2
Xinput67 wdata[67] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_1
XFILLER_0_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput56 wdata[57] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_1
Xhold807 instance_0.mem\[1\]\[48\] VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__dlygate4sd3_1
Xhold818 instance_0.mem\[0\]\[37\] VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__dlygate4sd3_1
X_3461_ _0902_ net927 _1656_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__mux2_1
Xhold829 instance_0.mem\[2\]\[69\] VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3392_ _0832_ net629 _1621_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__mux2_1
X_2412_ net16 VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__clkbuf_2
X_2343_ _0903_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
X_2274_ net49 VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4013_ _1964_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_17_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4846_ clknet_leaf_0_clk _0682_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[64\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4777_ clknet_leaf_57_clk _0613_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3728_ _1808_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__clkbuf_1
X_3659_ net569 _0943_ _1766_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2961_ instance_1.mem\[1\]\[21\] _1349_ _1278_ instance_1.mem\[3\]\[21\] _1331_ VGND
+ VGND VPWR VPWR _1356_ sky130_fd_sc_hd__a221o_1
X_4700_ clknet_leaf_59_clk _0536_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4631_ clknet_leaf_59_clk _0467_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_2892_ instance_1.mem\[1\]\[4\] _1272_ _1262_ instance_1.mem\[3\]\[4\] VGND VGND
+ VPWR VPWR _1304_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_60_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4562_ clknet_leaf_55_clk _0398_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_4493_ clknet_leaf_55_clk _0329_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold604 instance_1.mem\[0\]\[14\] VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__dlygate4sd3_1
X_3513_ net502 _0956_ _1686_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__mux2_1
Xhold615 instance_1.mem\[0\]\[48\] VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__dlygate4sd3_1
Xhold626 instance_1.mem\[2\]\[26\] VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__dlygate4sd3_1
Xhold637 instance_1.mem\[0\]\[43\] VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__dlygate4sd3_1
Xhold648 instance_0.mem\[2\]\[62\] VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlygate4sd3_1
X_3444_ _0884_ net419 _1649_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_6_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
Xhold659 instance_1.mem\[0\]\[25\] VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__dlygate4sd3_1
X_3375_ _1615_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__clkbuf_1
X_2326_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__clkbuf_4
X_2257_ _0844_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_68_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2188_ instance_0.rdata\[64\] instance_1.rdata\[64\] _0793_ VGND VGND VPWR VPWR _0798_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_23_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4829_ clknet_leaf_16_clk _0665_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3160_ _1490_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__buf_2
X_2111_ instance_0.rdata\[29\] instance_1.rdata\[29\] _0750_ VGND VGND VPWR VPWR _0756_
+ sky130_fd_sc_hd__mux2_1
X_3091_ instance_1.mem\[0\]\[55\] _1096_ _1437_ instance_1.mem\[2\]\[55\] VGND VGND
+ VPWR VPWR _1452_ sky130_fd_sc_hd__a22o_1
XFILLER_0_55_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1 instance_0.rdata\[46\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_65_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3993_ _1953_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2944_ net255 _1319_ _1341_ _1342_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__o22a_1
XFILLER_0_17_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2875_ _1070_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_25_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4614_ clknet_leaf_8_clk _0450_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[48\] sky130_fd_sc_hd__dfxtp_1
Xhold401 instance_1.mem\[3\]\[33\] VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4545_ clknet_leaf_8_clk _0381_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[51\] sky130_fd_sc_hd__dfxtp_1
Xhold434 instance_1.rdata\[6\] VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__dlygate4sd3_1
Xhold423 instance_1.mem\[1\]\[69\] VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__dlygate4sd3_1
Xhold412 instance_1.mem\[1\]\[58\] VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold445 instance_1.mem\[0\]\[20\] VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__dlygate4sd3_1
Xhold467 instance_1.rdata\[63\] VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__dlygate4sd3_1
Xhold456 instance_0.mem\[3\]\[57\] VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__dlygate4sd3_1
X_4476_ clknet_leaf_1_clk _0312_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[54\] sky130_fd_sc_hd__dfxtp_1
Xhold478 instance_0.mem\[0\]\[24\] VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__dlygate4sd3_1
Xhold489 instance_1.mem\[0\]\[15\] VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3427_ _0867_ net738 _1642_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__mux2_1
X_3358_ _1577_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__buf_2
X_2309_ net61 VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__buf_1
X_3289_ _0888_ net484 _1562_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2660_ instance_0.mem\[3\]\[20\] _1119_ _1127_ instance_0.mem\[2\]\[20\] VGND VGND
+ VPWR VPWR _1128_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2591_ _1024_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4330_ clknet_leaf_10_clk net274 VGND VGND VPWR VPWR instance_0.rdata\[52\] sky130_fd_sc_hd__dfxtp_1
X_4261_ clknet_leaf_2_clk _0097_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3212_ _1490_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__buf_2
X_4192_ clknet_leaf_5_clk _0028_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[58\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_78_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3143_ net478 _1487_ _1287_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3074_ net303 _1430_ _1438_ _1439_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__o22a_1
X_3976_ _1944_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__clkbuf_1
X_2927_ instance_1.mem\[0\]\[13\] _1276_ _1329_ instance_1.mem\[2\]\[13\] VGND VGND
+ VPWR VPWR _1330_ sky130_fd_sc_hd__a22o_1
X_2858_ instance_0.mem\[0\]\[69\] _1276_ _1268_ instance_0.mem\[2\]\[69\] VGND VGND
+ VPWR VPWR _1277_ sky130_fd_sc_hd__a22o_1
Xhold220 _0141_ VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2789_ instance_0.mem\[1\]\[51\] _1225_ _1099_ instance_0.mem\[2\]\[51\] VGND VGND
+ VPWR VPWR _1226_ sky130_fd_sc_hd__a22o_1
X_4528_ clknet_leaf_27_clk _0364_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[34\] sky130_fd_sc_hd__dfxtp_1
Xhold242 instance_1.rdata\[47\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__dlygate4sd3_1
Xhold253 instance_1.mem\[1\]\[0\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__dlygate4sd3_1
Xhold231 instance_1.mem\[3\]\[14\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__dlygate4sd3_1
Xhold286 instance_1.mem\[2\]\[15\] VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__dlygate4sd3_1
Xhold275 instance_0.mem\[3\]\[14\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__dlygate4sd3_1
Xhold264 instance_1.mem\[3\]\[51\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
X_4459_ clknet_leaf_21_clk _0295_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[37\] sky130_fd_sc_hd__dfxtp_1
Xhold297 instance_0.mem\[3\]\[6\] VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_47_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3830_ _1864_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__clkbuf_1
X_3761_ _1826_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__clkbuf_1
X_2712_ net243 _1149_ _1164_ _1167_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3692_ net498 net28 _1787_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2643_ net219 _1104_ _1114_ _1115_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_10_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2574_ _1035_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__clkbuf_2
X_4313_ clknet_leaf_25_clk net350 VGND VGND VPWR VPWR instance_0.rdata\[35\] sky130_fd_sc_hd__dfxtp_1
X_4244_ clknet_leaf_18_clk _0080_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_4175_ clknet_leaf_16_clk _0011_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_3126_ _1476_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3057_ net561 _1426_ _1344_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_81_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3959_ _1935_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_182 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2290_ net54 VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_47_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4862_ clknet_leaf_38_clk _0698_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3813_ _1855_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__clkbuf_1
XANTENNA_15 net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4793_ clknet_leaf_43_clk _0629_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3744_ _1817_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3675_ _1779_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__clkbuf_1
Xoutput100 net100 VGND VGND VPWR VPWR rdata[30] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2626_ _1042_ _1043_ instance_0.mem\[3\]\[12\] VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__and3_1
Xoutput111 net111 VGND VGND VPWR VPWR rdata[40] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput133 net133 VGND VGND VPWR VPWR rdata[60] sky130_fd_sc_hd__clkbuf_4
Xoutput122 net122 VGND VGND VPWR VPWR rdata[50] sky130_fd_sc_hd__clkbuf_4
X_2557_ instance_0.mem\[0\]\[0\] _1037_ _1040_ instance_0.mem\[2\]\[0\] _1044_ VGND
+ VGND VPWR VPWR _1045_ sky130_fd_sc_hd__a221o_1
Xoutput144 net144 VGND VGND VPWR VPWR rdata[70] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2488_ _0856_ net667 _0995_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__mux2_1
X_4227_ clknet_leaf_34_clk _0063_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_4158_ net736 net23 _2039_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3109_ instance_1.mem\[0\]\[60\] instance_1.mem\[1\]\[60\] instance_1.mem\[2\]\[60\]
+ instance_1.mem\[3\]\[60\] _1440_ _1464_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__mux4_1
X_4089_ _0894_ net596 _2004_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_57_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput13 wdata[18] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
Xinput24 wdata[28] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput35 wdata[38] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput46 wdata[48] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_1
Xhold808 instance_0.mem\[1\]\[47\] VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__dlygate4sd3_1
Xinput68 wdata[68] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__buf_1
XFILLER_0_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold819 instance_0.mem\[0\]\[64\] VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__dlygate4sd3_1
Xinput57 wdata[58] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_1
X_3460_ _1661_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__clkbuf_1
X_3391_ _1624_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__clkbuf_1
X_2411_ _0951_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_2342_ net680 _0902_ _0892_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4012_ _0817_ net757 _1961_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__mux2_1
X_2273_ _0855_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4845_ clknet_leaf_57_clk _0681_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_4776_ clknet_leaf_54_clk _0612_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_3727_ net430 net45 _1802_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3658_ _1770_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2609_ _1038_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__clkbuf_4
X_3589_ _1732_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2960_ instance_1.mem\[0\]\[21\] _1276_ _1329_ instance_1.mem\[2\]\[21\] VGND VGND
+ VPWR VPWR _1355_ sky130_fd_sc_hd__a22o_1
X_2891_ net295 _1294_ _1300_ _1303_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__o22a_1
XFILLER_0_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4630_ clknet_leaf_4_clk _0466_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[64\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4561_ clknet_leaf_57_clk _0397_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold627 instance_1.mem\[1\]\[33\] VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__dlygate4sd3_1
Xhold605 instance_0.mem\[3\]\[63\] VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__dlygate4sd3_1
X_4492_ clknet_leaf_55_clk _0328_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[70\] sky130_fd_sc_hd__dfxtp_1
Xhold616 instance_0.mem\[2\]\[15\] VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__dlygate4sd3_1
X_3512_ _1690_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__clkbuf_1
X_3443_ _1652_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__clkbuf_1
Xhold638 instance_1.mem\[0\]\[21\] VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__dlygate4sd3_1
Xhold649 instance_1.mem\[2\]\[19\] VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__dlygate4sd3_1
X_3374_ _0815_ net777 _1613_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2325_ _0811_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__buf_2
XFILLER_0_85_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2256_ net491 _0843_ _0839_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2187_ _0797_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4828_ clknet_leaf_13_clk _0664_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4759_ clknet_leaf_12_clk _0595_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[49\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2110_ _0755_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_1
X_3090_ net245 _1430_ _1449_ _1451_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__o22a_1
Xhold2 _0160_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3992_ _0958_ net361 _1947_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2943_ instance_1.mem\[1\]\[17\] _1315_ _1241_ instance_1.mem\[0\]\[17\] _1331_ VGND
+ VGND VPWR VPWR _1342_ sky130_fd_sc_hd__a221o_1
XFILLER_0_44_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2874_ _1289_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
X_4613_ clknet_leaf_16_clk _0449_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold402 instance_1.mem\[0\]\[10\] VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4544_ clknet_leaf_11_clk _0380_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[50\] sky130_fd_sc_hd__dfxtp_1
Xhold424 instance_0.mem\[3\]\[30\] VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__dlygate4sd3_1
Xhold435 instance_1.rdata\[69\] VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__dlygate4sd3_1
Xhold413 instance_1.rdata\[46\] VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__dlygate4sd3_1
Xhold446 instance_0.mem\[3\]\[34\] VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__dlygate4sd3_1
Xhold457 instance_0.mem\[2\]\[11\] VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__dlygate4sd3_1
Xhold468 instance_1.mem\[3\]\[13\] VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4475_ clknet_leaf_11_clk _0311_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[53\] sky130_fd_sc_hd__dfxtp_1
Xhold479 instance_1.rdata\[62\] VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__dlygate4sd3_1
X_3426_ _1643_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__clkbuf_1
X_3357_ _1605_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__clkbuf_1
X_2308_ _0879_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_3288_ _1567_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__clkbuf_1
X_2239_ net36 VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_0_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2590_ instance_0.mem\[0\]\[6\] instance_0.mem\[1\]\[6\] instance_0.mem\[2\]\[6\]
+ instance_0.mem\[3\]\[6\] _1069_ _1071_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4260_ clknet_leaf_11_clk _0096_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_3211_ _1525_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
X_4191_ clknet_leaf_3_clk _0027_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_3142_ instance_1.mem\[0\]\[71\] instance_1.mem\[1\]\[71\] instance_1.mem\[2\]\[71\]
+ instance_1.mem\[3\]\[71\] _1041_ _1043_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_78_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3073_ instance_1.mem\[1\]\[50\] _1418_ _1432_ instance_1.mem\[3\]\[50\] _1433_ VGND
+ VGND VPWR VPWR _1439_ sky130_fd_sc_hd__a221o_1
XFILLER_0_82_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3975_ _0941_ net637 _1940_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2926_ _1087_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__clkbuf_2
X_2857_ _1059_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold210 _0193_ VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
X_2788_ _1076_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__buf_2
X_4527_ clknet_leaf_27_clk _0363_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[33\] sky130_fd_sc_hd__dfxtp_1
Xhold243 instance_1.mem\[1\]\[60\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__dlygate4sd3_1
Xhold221 instance_0.rdata\[13\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold232 instance_1.mem\[3\]\[23\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__dlygate4sd3_1
Xhold276 instance_0.mem\[3\]\[43\] VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__dlygate4sd3_1
X_4458_ clknet_leaf_19_clk _0294_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[36\] sky130_fd_sc_hd__dfxtp_1
Xhold265 instance_1.mem\[3\]\[28\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__dlygate4sd3_1
Xhold254 instance_1.mem\[1\]\[18\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__dlygate4sd3_1
Xhold287 instance_1.mem\[1\]\[22\] VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__dlygate4sd3_1
X_3409_ _0849_ net663 _1628_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__mux2_1
Xhold298 instance_1.mem\[3\]\[25\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__dlygate4sd3_1
X_4389_ clknet_leaf_17_clk net356 VGND VGND VPWR VPWR instance_1.rdata\[39\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_5_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_75_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3760_ net471 net62 _1823_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__mux2_1
X_2711_ instance_0.mem\[1\]\[32\] _1140_ _1123_ instance_0.mem\[0\]\[32\] _1166_ VGND
+ VGND VPWR VPWR _1167_ sky130_fd_sc_hd__a221o_1
X_3691_ _1788_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2642_ instance_0.mem\[0\]\[15\] _1067_ _1080_ instance_0.mem\[2\]\[15\] _1091_ VGND
+ VGND VPWR VPWR _1115_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_10_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2573_ net247 _1026_ _1054_ _1058_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__o22a_1
X_4312_ clknet_leaf_27_clk net170 VGND VGND VPWR VPWR instance_0.rdata\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4243_ clknet_leaf_21_clk _0079_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_4174_ clknet_leaf_7_clk _0010_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_3125_ net548 _1475_ _1446_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3056_ instance_1.mem\[0\]\[46\] instance_1.mem\[1\]\[46\] instance_1.mem\[2\]\[46\]
+ instance_1.mem\[3\]\[46\] _1335_ _1375_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_18_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3958_ _0924_ net909 _1933_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2909_ _1165_ _1161_ instance_1.mem\[3\]\[8\] VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__and3_1
X_3889_ net708 net46 _1896_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4861_ clknet_leaf_51_clk _0697_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_15_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_25_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3812_ net735 net8 _1853_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__mux2_1
XANTENNA_16 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4792_ clknet_leaf_46_clk _0628_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_3743_ net640 net53 _1816_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3674_ net439 _0958_ _1773_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__mux2_1
Xoutput101 net101 VGND VGND VPWR VPWR rdata[31] sky130_fd_sc_hd__clkbuf_4
X_2625_ instance_0.mem\[2\]\[12\] _1100_ _1031_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__a21o_1
XFILLER_0_42_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput112 net112 VGND VGND VPWR VPWR rdata[41] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput134 net134 VGND VGND VPWR VPWR rdata[61] sky130_fd_sc_hd__clkbuf_4
Xoutput123 net123 VGND VGND VPWR VPWR rdata[51] sky130_fd_sc_hd__clkbuf_4
X_2556_ _1042_ _1043_ instance_0.mem\[3\]\[0\] VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__and3_1
Xoutput145 net145 VGND VGND VPWR VPWR rdata[71] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_34_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2487_ _0997_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4226_ clknet_leaf_35_clk _0062_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4157_ _2042_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__clkbuf_1
X_3108_ _1034_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__buf_2
X_4088_ _2005_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__clkbuf_1
X_3039_ _1412_ _1413_ _1414_ _1293_ net187 VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__o32a_1
XFILLER_0_77_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_43_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_52_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput36 wdata[39] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_1
Xinput25 wdata[29] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
Xinput14 wdata[19] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_70_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput69 wdata[69] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__buf_1
Xhold809 instance_0.mem\[2\]\[68\] VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__dlygate4sd3_1
Xinput58 wdata[59] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__buf_1
Xinput47 wdata[49] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_1
X_2410_ _0950_ net769 _0948_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__mux2_1
X_3390_ _0830_ net709 _1621_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2341_ net72 VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2272_ net545 _0854_ _0852_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__mux2_1
X_4011_ _1963_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4844_ clknet_leaf_59_clk _0680_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4775_ clknet_leaf_58_clk _0611_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3726_ _1807_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3657_ net434 _0941_ _1766_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__mux2_1
X_2608_ net165 _1075_ _1085_ _1086_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__o22a_1
X_3588_ net451 _0869_ _1729_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__mux2_1
X_2539_ _0810_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__buf_2
X_4209_ clknet_leaf_50_clk _0045_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2890_ instance_1.mem\[1\]\[3\] _1260_ _1274_ instance_1.mem\[2\]\[3\] _1302_ VGND
+ VGND VPWR VPWR _1303_ sky130_fd_sc_hd__a221o_1
XFILLER_0_56_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_60_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4560_ clknet_leaf_54_clk _0396_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4491_ clknet_leaf_55_clk _0327_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[69\] sky130_fd_sc_hd__dfxtp_1
Xhold606 instance_1.mem\[0\]\[6\] VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__dlygate4sd3_1
Xhold617 instance_1.mem\[0\]\[4\] VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__dlygate4sd3_1
X_3511_ net662 _0954_ _1686_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__mux2_1
Xhold628 instance_0.rdata\[30\] VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dlygate4sd3_1
X_3442_ _0882_ net796 _1649_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__mux2_1
Xhold639 instance_1.mem\[0\]\[52\] VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__dlygate4sd3_1
X_3373_ _1614_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__clkbuf_1
X_2324_ net66 VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__buf_1
XFILLER_0_40_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2255_ net42 VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_68_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2186_ instance_0.rdata\[63\] instance_1.rdata\[63\] _0793_ VGND VGND VPWR VPWR _0797_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4827_ clknet_leaf_13_clk _0663_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4758_ clknet_leaf_8_clk _0594_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_3709_ _1798_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__clkbuf_1
X_4689_ clknet_leaf_10_clk _0525_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold3 instance_0.rdata\[63\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_65_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3991_ _1952_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_73_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2942_ instance_1.mem\[3\]\[17\] _1320_ _1329_ instance_1.mem\[2\]\[17\] VGND VGND
+ VPWR VPWR _1341_ sky130_fd_sc_hd__a22o_1
XFILLER_0_57_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2873_ net454 _1284_ _1288_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__mux2_1
X_4612_ clknet_leaf_13_clk _0448_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4543_ clknet_leaf_12_clk _0379_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[49\] sky130_fd_sc_hd__dfxtp_1
Xhold436 instance_1.mem\[2\]\[33\] VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__dlygate4sd3_1
Xhold414 instance_1.mem\[1\]\[42\] VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__dlygate4sd3_1
Xhold425 instance_1.mem\[3\]\[42\] VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__dlygate4sd3_1
Xhold403 instance_1.mem\[3\]\[57\] VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__dlygate4sd3_1
Xhold458 instance_0.mem\[0\]\[45\] VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__dlygate4sd3_1
Xhold469 instance_0.mem\[1\]\[64\] VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__dlygate4sd3_1
X_4474_ clknet_leaf_10_clk _0310_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[52\] sky130_fd_sc_hd__dfxtp_1
Xhold447 instance_1.mem\[0\]\[46\] VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3425_ _0864_ net872 _1642_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__mux2_1
X_3356_ _0958_ net876 _1599_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__mux2_1
X_2307_ net391 _0877_ _0878_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__mux2_1
X_3287_ _0886_ net617 _1562_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__mux2_1
X_2238_ _0831_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
X_2169_ instance_0.rdata\[55\] instance_1.rdata\[55\] _0786_ VGND VGND VPWR VPWR _0788_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_0_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3210_ _0971_ net829 _1519_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__mux2_1
X_4190_ clknet_leaf_3_clk _0026_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_3141_ net337 _1293_ _1485_ _1486_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_78_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3072_ instance_1.mem\[0\]\[50\] _1371_ _1437_ instance_1.mem\[2\]\[50\] VGND VGND
+ VPWR VPWR _1438_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_33_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3974_ _1943_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__clkbuf_1
X_2925_ net201 _1319_ _1327_ _1328_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__o22a_1
X_2856_ net231 _1211_ _1273_ _1275_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__o22a_1
XFILLER_0_79_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold211 instance_1.rdata\[36\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
Xhold200 _0216_ VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
X_2787_ instance_0.mem\[0\]\[51\] _1052_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__and2_1
Xhold222 _0127_ VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
Xhold233 instance_0.mem\[3\]\[56\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__dlygate4sd3_1
X_4526_ clknet_leaf_24_clk _0362_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[32\] sky130_fd_sc_hd__dfxtp_1
Xhold244 instance_1.mem\[1\]\[31\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__dlygate4sd3_1
Xhold255 instance_0.rdata\[43\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__dlygate4sd3_1
X_4457_ clknet_leaf_28_clk _0293_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold266 instance_1.mem\[2\]\[18\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__dlygate4sd3_1
Xhold277 instance_1.mem\[2\]\[52\] VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__dlygate4sd3_1
Xhold288 instance_1.mem\[1\]\[10\] VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__dlygate4sd3_1
Xhold299 instance_1.mem\[1\]\[51\] VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__dlygate4sd3_1
X_3408_ _1633_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__clkbuf_1
X_4388_ clknet_leaf_26_clk net206 VGND VGND VPWR VPWR instance_1.rdata\[38\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_5_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3339_ _0941_ net764 _1592_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_86_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_56_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_56_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_47_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2710_ _1165_ _1161_ instance_0.mem\[3\]\[32\] VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__and3_1
X_3690_ net691 net27 _1787_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2641_ instance_0.mem\[1\]\[15\] _1078_ _1113_ instance_0.mem\[3\]\[15\] VGND VGND
+ VPWR VPWR _1114_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_10_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_162 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2572_ instance_0.mem\[1\]\[2\] _1056_ _1040_ instance_0.mem\[2\]\[2\] _1057_ VGND
+ VGND VPWR VPWR _1058_ sky130_fd_sc_hd__a221o_1
X_4311_ clknet_leaf_27_clk net372 VGND VGND VPWR VPWR instance_0.rdata\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4242_ clknet_leaf_19_clk _0078_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_4173_ clknet_leaf_17_clk _0009_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_3124_ instance_1.mem\[0\]\[65\] instance_1.mem\[1\]\[65\] instance_1.mem\[2\]\[65\]
+ instance_1.mem\[3\]\[65\] _1440_ _1464_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_2_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3055_ net305 _1407_ _1424_ _1425_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__o22a_1
Xclkbuf_leaf_47_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_47_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3957_ _1934_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2908_ _1098_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3888_ _1881_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__buf_2
X_2839_ _1093_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__buf_2
XFILLER_0_33_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4509_ clknet_leaf_39_clk _0345_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_38_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_38_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_44_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_29_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_29_clk sky130_fd_sc_hd__clkbuf_8
X_4860_ clknet_leaf_48_clk _0696_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_15_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3811_ _1854_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__clkbuf_1
X_4791_ clknet_leaf_47_clk _0627_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_17 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3742_ _1794_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__buf_2
XFILLER_0_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3673_ _1778_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2624_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__clkbuf_4
Xoutput102 net102 VGND VGND VPWR VPWR rdata[32] sky130_fd_sc_hd__clkbuf_4
Xoutput113 net113 VGND VGND VPWR VPWR rdata[42] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput124 net124 VGND VGND VPWR VPWR rdata[52] sky130_fd_sc_hd__clkbuf_4
Xoutput135 net135 VGND VGND VPWR VPWR rdata[62] sky130_fd_sc_hd__clkbuf_4
Xoutput146 net146 VGND VGND VPWR VPWR rdata[7] sky130_fd_sc_hd__clkbuf_4
X_2555_ _1034_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2486_ _0854_ net866 _0995_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__mux2_1
X_4225_ clknet_leaf_33_clk _0061_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_4156_ net599 net22 _2039_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__mux2_1
X_3107_ net353 _1454_ _1462_ _1463_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__o22a_1
X_4087_ _0890_ net650 _2004_ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__mux2_1
X_3038_ instance_1.mem\[0\]\[40\] _1052_ _1099_ instance_1.mem\[2\]\[40\] VGND VGND
+ VPWR VPWR _1414_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput26 wdata[2] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput15 wdata[1] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
Xinput37 wdata[3] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput48 wdata[4] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_1
Xinput59 wdata[5] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_1
X_2340_ _0901_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_2271_ net47 VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4010_ _0815_ net848 _1961_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4843_ clknet_leaf_1_clk _0679_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4774_ clknet_leaf_0_clk _0610_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[64\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_479 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3725_ net395 net44 _1802_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_9_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
X_3656_ _1769_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__clkbuf_1
X_2607_ instance_0.mem\[0\]\[9\] _1067_ _1080_ instance_0.mem\[2\]\[9\] _1057_ VGND
+ VGND VPWR VPWR _1086_ sky130_fd_sc_hd__a221o_1
X_3587_ _1731_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2538_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__clkbuf_2
X_2469_ _0987_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
X_4208_ clknet_leaf_52_clk _0044_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4139_ net402 net13 _2032_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_60_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3510_ _1689_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__clkbuf_1
Xhold607 instance_0.mem\[2\]\[43\] VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__dlygate4sd3_1
Xhold618 instance_1.mem\[3\]\[36\] VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4490_ clknet_leaf_54_clk _0326_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_3441_ _1651_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__clkbuf_1
Xhold629 instance_0.mem\[2\]\[31\] VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dlygate4sd3_1
X_3372_ _0807_ net620 _1613_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__mux2_1
X_2323_ _0889_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
X_2254_ _0842_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_68_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2185_ _0796_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4826_ clknet_leaf_13_clk _0662_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4757_ clknet_leaf_13_clk _0593_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[47\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3708_ net531 net35 _1795_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__mux2_1
X_4688_ clknet_leaf_11_clk _0524_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3639_ _1760_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_89_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold4 _0177_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3990_ _0956_ net918 _1947_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_73_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2941_ net217 _1319_ _1338_ _1340_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__o22a_1
XFILLER_0_57_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4611_ clknet_leaf_14_clk _0447_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_2872_ _1287_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__clkbuf_4
X_4542_ clknet_leaf_8_clk _0378_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[48\] sky130_fd_sc_hd__dfxtp_1
Xhold426 instance_1.mem\[3\]\[44\] VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__dlygate4sd3_1
Xhold404 instance_0.mem\[3\]\[11\] VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__dlygate4sd3_1
Xhold415 instance_0.mem\[3\]\[55\] VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__dlygate4sd3_1
X_4473_ clknet_leaf_8_clk _0309_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[51\] sky130_fd_sc_hd__dfxtp_1
Xhold437 instance_0.mem\[0\]\[38\] VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__dlygate4sd3_1
Xhold448 instance_1.mem\[0\]\[67\] VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__dlygate4sd3_1
Xhold459 instance_0.mem\[3\]\[2\] VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__dlygate4sd3_1
X_3424_ _1620_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__buf_2
XFILLER_0_40_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3355_ _1604_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__clkbuf_1
X_3286_ _1566_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__clkbuf_1
X_2306_ _0812_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__clkbuf_4
X_2237_ net440 _0830_ _0826_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2168_ _0787_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2099_ _0749_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_0_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4809_ clknet_leaf_30_clk _0645_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_70_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ instance_1.mem\[0\]\[70\] _1052_ _1450_ instance_1.mem\[2\]\[70\] _1301_ VGND
+ VGND VPWR VPWR _1486_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_78_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3071_ _1039_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__buf_2
XFILLER_0_82_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3973_ _0939_ net752 _1940_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2924_ instance_1.mem\[1\]\[12\] _1315_ _1316_ instance_1.mem\[2\]\[12\] _1302_ VGND
+ VGND VPWR VPWR _1328_ sky130_fd_sc_hd__a221o_1
XFILLER_0_57_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2855_ instance_0.mem\[0\]\[68\] _1270_ _1274_ instance_0.mem\[2\]\[68\] _1266_ VGND
+ VGND VPWR VPWR _1275_ sky130_fd_sc_hd__a221o_1
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold201 instance_0.rdata\[35\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
X_2786_ instance_0.mem\[3\]\[51\] _1047_ _1030_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__a21o_1
X_4525_ clknet_leaf_24_clk _0361_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xhold223 instance_0.rdata\[33\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold212 _0222_ VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
Xhold234 instance_1.mem\[2\]\[60\] VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlygate4sd3_1
Xhold267 instance_0.rdata\[45\] VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__dlygate4sd3_1
X_4456_ clknet_leaf_27_clk _0292_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[34\] sky130_fd_sc_hd__dfxtp_1
Xhold256 instance_1.mem\[3\]\[60\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlygate4sd3_1
Xhold278 instance_1.mem\[3\]\[18\] VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__dlygate4sd3_1
Xhold245 instance_0.rdata\[19\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4387_ clknet_leaf_21_clk net334 VGND VGND VPWR VPWR instance_1.rdata\[37\] sky130_fd_sc_hd__dfxtp_1
Xhold289 instance_0.mem\[3\]\[32\] VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__dlygate4sd3_1
X_3407_ _0847_ net452 _1628_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__mux2_1
X_3338_ _1595_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_5_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3269_ _1557_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold790 instance_0.mem\[3\]\[71\] VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_75_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2640_ _1047_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_10_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2571_ _1030_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__buf_2
XFILLER_0_22_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4310_ clknet_leaf_24_clk net244 VGND VGND VPWR VPWR instance_0.rdata\[32\] sky130_fd_sc_hd__dfxtp_1
X_4241_ clknet_leaf_28_clk _0077_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_4172_ clknet_leaf_26_clk _0008_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[38\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3123_ net269 _1454_ _1473_ _1474_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__o22a_1
X_3054_ instance_1.mem\[1\]\[45\] _1418_ _1405_ instance_1.mem\[0\]\[45\] _1410_ VGND
+ VGND VPWR VPWR _1425_ sky130_fd_sc_hd__a221o_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3956_ _0921_ net754 _1933_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2907_ _1076_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__buf_2
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3887_ _1895_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2838_ net207 _1248_ _1259_ _1261_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__o22a_1
X_2769_ _1073_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__buf_2
X_4508_ clknet_leaf_42_clk _0344_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_4439_ clknet_leaf_40_clk _0275_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3810_ net376 net7 _1853_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__mux2_1
X_4790_ clknet_leaf_38_clk _0626_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_3741_ _1815_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__clkbuf_1
XANTENNA_18 _1042_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3672_ net568 _0956_ _1773_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2623_ _1098_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__clkbuf_4
Xoutput103 net103 VGND VGND VPWR VPWR rdata[33] sky130_fd_sc_hd__clkbuf_4
Xoutput114 net114 VGND VGND VPWR VPWR rdata[43] sky130_fd_sc_hd__clkbuf_4
X_2554_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__buf_2
Xoutput125 net125 VGND VGND VPWR VPWR rdata[53] sky130_fd_sc_hd__clkbuf_4
Xoutput136 net136 VGND VGND VPWR VPWR rdata[63] sky130_fd_sc_hd__clkbuf_4
Xoutput147 net147 VGND VGND VPWR VPWR rdata[8] sky130_fd_sc_hd__clkbuf_4
X_2485_ _0996_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
X_4224_ clknet_leaf_36_clk _0060_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_4155_ _2041_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__clkbuf_1
X_3106_ instance_1.mem\[0\]\[59\] _1401_ _1450_ instance_1.mem\[2\]\[59\] _1456_ VGND
+ VGND VPWR VPWR _1463_ sky130_fd_sc_hd__a221o_1
XFILLER_0_37_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4086_ _1968_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__buf_2
X_3037_ instance_1.mem\[1\]\[40\] _1027_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3939_ _1923_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput27 wdata[30] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
XFILLER_0_24_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput16 wdata[20] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput38 wdata[40] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
Xinput49 wdata[50] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_1
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2270_ _0853_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4842_ clknet_leaf_59_clk _0678_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4773_ clknet_leaf_57_clk _0609_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_3724_ _1806_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__clkbuf_1
X_3655_ net427 _0939_ _1766_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2606_ instance_0.mem\[1\]\[9\] _1078_ _1048_ instance_0.mem\[3\]\[9\] VGND VGND
+ VPWR VPWR _1085_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3586_ net761 _0867_ _1729_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__mux2_1
X_2537_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__clkbuf_4
X_2468_ _0836_ net820 _0981_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4207_ clknet_leaf_48_clk _0043_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2399_ net11 VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4138_ _0891_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__buf_2
X_4069_ _0873_ net587 _1990_ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_54_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold608 instance_1.mem\[0\]\[50\] VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__dlygate4sd3_1
Xhold619 instance_1.mem\[2\]\[36\] VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__dlygate4sd3_1
X_3440_ _0880_ net405 _1649_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__mux2_1
X_3371_ _1577_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__buf_2
X_2322_ net556 _0888_ _0878_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2253_ net718 _0841_ _0839_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__mux2_1
X_2184_ instance_0.rdata\[62\] instance_1.rdata\[62\] _0793_ VGND VGND VPWR VPWR _0796_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4825_ clknet_leaf_13_clk _0661_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4756_ clknet_leaf_9_clk _0592_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3707_ _1797_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__clkbuf_1
X_4687_ clknet_leaf_12_clk _0523_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_3638_ net461 _0921_ _1759_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3569_ _1721_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_49_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_58_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold5 instance_0.rdata\[51\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_65_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2940_ instance_1.mem\[0\]\[16\] _1339_ _1316_ instance_1.mem\[2\]\[16\] _1331_ VGND
+ VGND VPWR VPWR _1340_ sky130_fd_sc_hd__a221o_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2871_ _1286_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__buf_2
X_4610_ clknet_leaf_14_clk _0446_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4541_ clknet_leaf_20_clk _0377_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[47\] sky130_fd_sc_hd__dfxtp_1
Xhold427 instance_0.mem\[0\]\[35\] VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__dlygate4sd3_1
Xhold416 instance_0.mem\[1\]\[60\] VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold405 instance_1.mem\[3\]\[2\] VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4472_ clknet_leaf_11_clk _0308_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[50\] sky130_fd_sc_hd__dfxtp_1
Xhold449 instance_1.mem\[0\]\[68\] VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__dlygate4sd3_1
Xhold438 instance_0.mem\[0\]\[58\] VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__dlygate4sd3_1
X_3423_ _1641_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__clkbuf_1
X_3354_ _0956_ net903 _1599_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__mux2_1
X_3285_ _0884_ net808 _1562_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__mux2_1
X_2305_ net60 VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2236_ net35 VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2167_ instance_0.rdata\[54\] instance_1.rdata\[54\] _0786_ VGND VGND VPWR VPWR _0787_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2098_ instance_0.rdata\[23\] instance_1.rdata\[23\] _0743_ VGND VGND VPWR VPWR _0749_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4808_ clknet_leaf_32_clk _0644_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4739_ clknet_leaf_29_clk _0575_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3070_ net291 _1430_ _1435_ _1436_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__o22a_1
XFILLER_0_77_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3972_ _1942_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2923_ instance_1.mem\[0\]\[12\] _1276_ _1311_ instance_1.mem\[3\]\[12\] VGND VGND
+ VPWR VPWR _1327_ sky130_fd_sc_hd__a22o_1
XFILLER_0_57_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2854_ _1098_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_41_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2785_ _1222_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
Xhold202 _0149_ VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
X_4524_ clknet_leaf_24_clk _0360_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
Xhold224 _0147_ VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
Xhold213 instance_1.mem\[0\]\[23\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
Xhold235 instance_1.mem\[3\]\[20\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__dlygate4sd3_1
X_4455_ clknet_leaf_28_clk _0291_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[33\] sky130_fd_sc_hd__dfxtp_1
Xhold257 instance_0.mem\[2\]\[61\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__dlygate4sd3_1
Xhold246 instance_0.mem\[3\]\[50\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__dlygate4sd3_1
Xhold268 instance_0.mem\[1\]\[19\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__dlygate4sd3_1
X_3406_ _1632_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__clkbuf_1
X_4386_ clknet_leaf_19_clk net360 VGND VGND VPWR VPWR instance_1.rdata\[36\] sky130_fd_sc_hd__dfxtp_1
Xhold279 instance_1.mem\[2\]\[14\] VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__dlygate4sd3_1
X_3337_ _0939_ net492 _1592_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_5_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3268_ _0867_ net534 _1555_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__mux2_1
X_3199_ _1490_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__buf_2
X_2219_ _0818_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold791 instance_0.mem\[1\]\[34\] VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold780 instance_0.mem\[1\]\[70\] VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_75_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2570_ _1055_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_10_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4240_ clknet_leaf_27_clk _0076_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_4171_ clknet_leaf_22_clk _0007_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_3122_ instance_1.mem\[1\]\[64\] _1225_ _1432_ instance_1.mem\[3\]\[64\] _1456_ VGND
+ VGND VPWR VPWR _1474_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_2_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3053_ instance_1.mem\[3\]\[45\] _1090_ _1408_ instance_1.mem\[2\]\[45\] VGND VGND
+ VPWR VPWR _1424_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_18_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3955_ _1925_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2906_ instance_1.mem\[0\]\[8\] _1053_ _1298_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__a21o_1
X_3886_ net878 net45 _1889_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2837_ instance_0.mem\[1\]\[64\] _1260_ _1231_ instance_0.mem\[2\]\[64\] _1242_ VGND
+ VGND VPWR VPWR _1261_ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2768_ instance_0.mem\[3\]\[46\] _1090_ _1050_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__a21o_1
X_2699_ net341 _1149_ _1156_ _1157_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__o22a_1
X_4507_ clknet_leaf_40_clk _0343_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4438_ clknet_leaf_40_clk _0274_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_4369_ clknet_leaf_33_clk net332 VGND VGND VPWR VPWR instance_1.rdata\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_19 _1071_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3740_ net871 net52 _1809_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3671_ _1777_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2622_ _1038_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__clkbuf_2
Xoutput104 net104 VGND VGND VPWR VPWR rdata[34] sky130_fd_sc_hd__clkbuf_4
Xoutput115 net115 VGND VGND VPWR VPWR rdata[44] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_70_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2553_ _0906_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__buf_2
Xoutput148 net148 VGND VGND VPWR VPWR rdata[9] sky130_fd_sc_hd__buf_2
XFILLER_0_10_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput137 net137 VGND VGND VPWR VPWR rdata[64] sky130_fd_sc_hd__clkbuf_4
Xoutput126 net126 VGND VGND VPWR VPWR rdata[54] sky130_fd_sc_hd__clkbuf_4
X_2484_ _0851_ net864 _0995_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__mux2_1
X_4223_ clknet_leaf_40_clk _0059_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_4154_ net495 net21 _2039_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__mux2_1
X_4085_ _2003_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__clkbuf_1
X_3105_ instance_1.mem\[1\]\[59\] _1448_ _1094_ instance_1.mem\[3\]\[59\] VGND VGND
+ VPWR VPWR _1462_ sky130_fd_sc_hd__a22o_1
X_3036_ instance_1.mem\[3\]\[40\] _1047_ _1301_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_12_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3938_ net938 net72 _1917_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3869_ net581 net36 _1882_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput28 wdata[31] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput17 wdata[21] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
Xinput39 wdata[41] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_1
XFILLER_0_24_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4841_ clknet_leaf_1_clk _0677_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4772_ clknet_leaf_58_clk _0608_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_3723_ net499 net43 _1802_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3654_ _1768_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__clkbuf_1
X_2605_ net267 _1075_ _1082_ _1084_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__o22a_1
XFILLER_0_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3585_ _1730_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2536_ _1023_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2467_ _0986_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
X_4206_ clknet_leaf_56_clk _0042_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2398_ _0942_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4137_ _2031_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__clkbuf_1
X_4068_ _1994_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__clkbuf_1
X_3019_ instance_1.mem\[0\]\[36\] _1339_ _1396_ instance_1.mem\[2\]\[36\] _1386_ VGND
+ VGND VPWR VPWR _1399_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_54_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold609 instance_1.mem\[0\]\[32\] VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__dlygate4sd3_1
X_3370_ _1612_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__clkbuf_1
X_2321_ net65 VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2252_ net41 VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_85_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2183_ _0795_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4824_ clknet_leaf_16_clk _0660_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4755_ clknet_leaf_14_clk _0591_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3706_ net701 net34 _1795_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4686_ clknet_leaf_8_clk _0522_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_3637_ _1751_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__clkbuf_4
X_3568_ net505 _0849_ _1715_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2519_ _1014_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
X_3499_ _1683_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_81_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold6 _0165_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_71_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2870_ _1285_ _0905_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__and2_1
XFILLER_0_57_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_10_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
X_4540_ clknet_leaf_20_clk _0376_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[46\] sky130_fd_sc_hd__dfxtp_1
Xhold406 instance_0.mem\[3\]\[54\] VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__dlygate4sd3_1
Xhold417 instance_1.mem\[0\]\[18\] VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4471_ clknet_leaf_12_clk _0307_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold439 instance_1.mem\[0\]\[58\] VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__dlygate4sd3_1
X_3422_ _0862_ net974 _1635_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__mux2_1
Xhold428 instance_0.rdata\[50\] VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__dlygate4sd3_1
X_3353_ _1603_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__clkbuf_1
X_3284_ _1565_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__clkbuf_1
X_2304_ _0876_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2235_ _0829_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_88_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2166_ _0764_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_36_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2097_ _0748_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4807_ clknet_leaf_32_clk _0643_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_2999_ _1383_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
X_4738_ clknet_leaf_28_clk _0574_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4669_ clknet_leaf_23_clk _0505_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_59_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_59_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_82_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3971_ _0937_ net973 _1940_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2922_ net325 _1319_ _1325_ _1326_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_33_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2853_ instance_0.mem\[1\]\[68\] _1272_ _1262_ instance_0.mem\[3\]\[68\] VGND VGND
+ VPWR VPWR _1273_ sky130_fd_sc_hd__a22o_1
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2784_ net576 _1221_ _1024_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4523_ clknet_leaf_29_clk _0359_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold203 instance_1.rdata\[66\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
Xhold214 _0209_ VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
Xhold225 instance_0.rdata\[31\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
Xhold236 instance_1.mem\[3\]\[1\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlygate4sd3_1
Xhold269 instance_1.mem\[1\]\[14\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__dlygate4sd3_1
Xhold258 instance_1.mem\[3\]\[68\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlygate4sd3_1
X_4454_ clknet_leaf_24_clk _0290_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[32\] sky130_fd_sc_hd__dfxtp_1
Xhold247 instance_1.mem\[2\]\[46\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__dlygate4sd3_1
X_3405_ _0845_ net513 _1628_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__mux2_1
X_4385_ clknet_leaf_25_clk net298 VGND VGND VPWR VPWR instance_1.rdata\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3336_ _1594_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__clkbuf_1
X_3267_ _1556_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__clkbuf_1
X_3198_ _1518_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
X_2218_ net673 _0817_ _0813_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_77_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2149_ instance_0.rdata\[46\] instance_1.rdata\[46\] _0772_ VGND VGND VPWR VPWR _0777_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_86_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold781 instance_1.mem\[0\]\[39\] VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__dlygate4sd3_1
Xhold770 instance_1.mem\[0\]\[22\] VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__dlygate4sd3_1
Xhold792 instance_0.mem\[2\]\[57\] VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4170_ clknet_leaf_19_clk _0006_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_3121_ instance_1.mem\[0\]\[64\] _1096_ _1437_ instance_1.mem\[2\]\[64\] VGND VGND
+ VPWR VPWR _1473_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3052_ net223 _1407_ _1422_ _1423_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__o22a_1
XFILLER_0_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3954_ _1932_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2905_ net357 _1294_ _1312_ _1313_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__o22a_1
X_3885_ _1894_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__clkbuf_1
X_2836_ _1055_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__buf_2
X_2767_ instance_0.mem\[1\]\[46\] _1027_ _1037_ instance_0.mem\[0\]\[46\] VGND VGND
+ VPWR VPWR _1209_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2698_ instance_0.mem\[1\]\[29\] _1140_ _1108_ instance_0.mem\[3\]\[29\] _1151_ VGND
+ VGND VPWR VPWR _1157_ sky130_fd_sc_hd__a221o_1
X_4506_ clknet_leaf_39_clk _0342_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_4437_ clknet_leaf_42_clk _0273_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_4368_ clknet_leaf_38_clk _0204_ VGND VGND VPWR VPWR instance_1.rdata\[18\] sky130_fd_sc_hd__dfxtp_1
X_3319_ _1577_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__buf_2
X_4299_ clknet_leaf_33_clk net364 VGND VGND VPWR VPWR instance_0.rdata\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_80_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3670_ net860 _0954_ _1773_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__mux2_1
X_2621_ net171 _1075_ _1095_ _1097_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__o22a_1
Xoutput116 net116 VGND VGND VPWR VPWR rdata[45] sky130_fd_sc_hd__clkbuf_4
Xoutput105 net105 VGND VGND VPWR VPWR rdata[35] sky130_fd_sc_hd__clkbuf_4
X_2552_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__buf_2
XFILLER_0_10_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput138 net138 VGND VGND VPWR VPWR rdata[65] sky130_fd_sc_hd__clkbuf_4
Xoutput127 net127 VGND VGND VPWR VPWR rdata[55] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4222_ clknet_leaf_38_clk _0058_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_2483_ _0980_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_91_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4153_ _2040_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__clkbuf_1
X_4084_ _0888_ net470 _1997_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__mux2_1
X_3104_ net173 _1454_ _1460_ _1461_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__o22a_1
XFILLER_0_37_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3035_ net355 _1407_ _1409_ _1411_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__o22a_1
X_3937_ _1922_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3868_ _1885_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__clkbuf_1
X_3799_ net713 net73 _1846_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__mux2_1
X_2819_ _1247_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 wdata[22] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
Xinput29 wdata[32] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_1
XFILLER_0_91_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4840_ clknet_leaf_5_clk _0676_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4771_ clknet_leaf_1_clk _0607_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_3722_ _1805_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__clkbuf_1
X_3653_ net555 _0937_ _1766_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2604_ instance_0.mem\[1\]\[8\] _1056_ _1080_ instance_0.mem\[2\]\[8\] _1083_ VGND
+ VGND VPWR VPWR _1084_ sky130_fd_sc_hd__a221o_1
XFILLER_0_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3584_ net840 _0864_ _1729_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__mux2_1
X_2535_ _0720_ _0808_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__and2b_1
X_2466_ _0834_ net847 _0981_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__mux2_1
X_4205_ clknet_leaf_56_clk _0041_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2397_ _0941_ net965 _0935_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__mux2_1
X_4136_ net666 net12 _2025_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__mux2_1
X_4067_ _0871_ net924 _1990_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__mux2_1
X_3018_ instance_1.mem\[1\]\[36\] _1362_ _1394_ instance_1.mem\[3\]\[36\] VGND VGND
+ VPWR VPWR _1398_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_54_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2320_ _0887_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_2251_ _0840_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
X_2182_ instance_0.rdata\[61\] instance_1.rdata\[61\] _0793_ VGND VGND VPWR VPWR _0795_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4823_ clknet_leaf_19_clk _0659_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4754_ clknet_leaf_14_clk _0590_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_3705_ _1796_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4685_ clknet_leaf_16_clk _0521_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3636_ _1758_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3567_ _1720_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__clkbuf_1
X_2518_ _0886_ net967 _1009_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__mux2_1
X_3498_ net438 _0941_ _1679_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__mux2_1
X_2449_ _0976_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
X_4119_ net685 net75 _2018_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_39_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold7 instance_1.rdata\[56\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold418 instance_0.mem\[2\]\[35\] VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold407 instance_1.mem\[2\]\[13\] VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__dlygate4sd3_1
X_4470_ clknet_leaf_8_clk _0306_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[48\] sky130_fd_sc_hd__dfxtp_1
Xhold429 instance_1.mem\[2\]\[9\] VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__dlygate4sd3_1
X_3421_ _1640_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3352_ _0954_ net751 _1599_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2303_ net945 _0875_ _0865_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__mux2_1
X_3283_ _0882_ net833 _1562_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__mux2_1
X_2234_ net486 _0828_ _0826_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2165_ _0785_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_64_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2096_ instance_0.rdata\[22\] instance_1.rdata\[22\] _0743_ VGND VGND VPWR VPWR _0748_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4806_ clknet_leaf_31_clk _0642_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2998_ net541 _1382_ _1344_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__mux2_1
X_4737_ clknet_leaf_29_clk _0573_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4668_ clknet_leaf_25_clk _0504_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3619_ _1748_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__clkbuf_1
X_4599_ clknet_leaf_26_clk _0435_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3970_ _1941_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__clkbuf_1
X_2921_ instance_1.mem\[1\]\[11\] _1315_ _1278_ instance_1.mem\[3\]\[11\] _1302_ VGND
+ VGND VPWR VPWR _1326_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_33_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2852_ _1077_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2783_ instance_0.mem\[0\]\[50\] instance_0.mem\[1\]\[50\] instance_0.mem\[2\]\[50\]
+ instance_0.mem\[3\]\[50\] _1186_ _1205_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__mux4_1
XFILLER_0_60_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4522_ clknet_leaf_29_clk _0358_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold204 _0252_ VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold215 instance_0.rdata\[21\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
X_4453_ clknet_leaf_24_clk _0289_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xhold226 _0145_ VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold248 instance_0.mem\[3\]\[45\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__dlygate4sd3_1
Xhold237 instance_1.mem\[1\]\[47\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__dlygate4sd3_1
X_3404_ _1631_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__clkbuf_1
Xhold259 instance_1.mem\[1\]\[62\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4384_ clknet_leaf_27_clk net240 VGND VGND VPWR VPWR instance_1.rdata\[34\] sky130_fd_sc_hd__dfxtp_1
X_3335_ _0937_ net861 _1592_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3266_ _0864_ net963 _1555_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__mux2_1
X_2217_ net29 VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3197_ _0958_ net888 _1512_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__mux2_1
X_2148_ _0776_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2079_ instance_0.rdata\[14\] instance_1.rdata\[14\] _0736_ VGND VGND VPWR VPWR _0739_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold782 instance_0.mem\[2\]\[27\] VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__dlygate4sd3_1
Xhold771 instance_0.mem\[1\]\[41\] VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__dlygate4sd3_1
Xhold760 instance_0.mem\[0\]\[31\] VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__dlygate4sd3_1
Xhold793 instance_0.mem\[0\]\[62\] VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_4_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3120_ _1472_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3051_ instance_1.mem\[1\]\[44\] _1418_ _1396_ instance_1.mem\[2\]\[44\] _1410_ VGND
+ VGND VPWR VPWR _1423_ sky130_fd_sc_hd__a221o_1
XFILLER_0_89_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3953_ _0919_ net699 _1926_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__mux2_1
X_2904_ instance_1.mem\[0\]\[7\] _1270_ _1274_ instance_1.mem\[2\]\[7\] _1302_ VGND
+ VGND VPWR VPWR _1313_ sky130_fd_sc_hd__a221o_1
XFILLER_0_42_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3884_ net703 net44 _1889_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__mux2_1
X_2835_ instance_0.mem\[0\]\[64\] _1189_ _1200_ instance_0.mem\[3\]\[64\] VGND VGND
+ VPWR VPWR _1259_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2766_ instance_0.mem\[2\]\[46\] _1099_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__and2_1
X_2697_ instance_0.mem\[0\]\[29\] _1060_ _1127_ instance_0.mem\[2\]\[29\] VGND VGND
+ VPWR VPWR _1156_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4505_ clknet_leaf_47_clk _0341_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4436_ clknet_leaf_42_clk _0272_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_4367_ clknet_leaf_41_clk net256 VGND VGND VPWR VPWR instance_1.rdata\[17\] sky130_fd_sc_hd__dfxtp_1
X_3318_ _1584_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__clkbuf_1
X_4298_ clknet_leaf_35_clk net196 VGND VGND VPWR VPWR instance_0.rdata\[20\] sky130_fd_sc_hd__dfxtp_1
X_3249_ _1546_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold590 instance_0.mem\[2\]\[55\] VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2620_ instance_0.mem\[1\]\[11\] _1056_ _1096_ instance_0.mem\[0\]\[11\] _1091_ VGND
+ VGND VPWR VPWR _1097_ sky130_fd_sc_hd__a221o_1
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput106 net106 VGND VGND VPWR VPWR rdata[36] sky130_fd_sc_hd__clkbuf_4
X_2551_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__buf_2
Xoutput117 net117 VGND VGND VPWR VPWR rdata[46] sky130_fd_sc_hd__clkbuf_4
X_2482_ _0994_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
Xoutput139 net139 VGND VGND VPWR VPWR rdata[66] sky130_fd_sc_hd__clkbuf_4
Xoutput128 net128 VGND VGND VPWR VPWR rdata[56] sky130_fd_sc_hd__clkbuf_4
X_4221_ clknet_leaf_42_clk _0057_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_91_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4152_ net500 net20 _2039_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__mux2_1
X_4083_ _2002_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__clkbuf_1
X_3103_ instance_1.mem\[1\]\[58\] _1225_ _1037_ instance_1.mem\[0\]\[58\] _1456_ VGND
+ VGND VPWR VPWR _1461_ sky130_fd_sc_hd__a221o_1
X_3034_ instance_1.mem\[1\]\[39\] _1385_ _1405_ instance_1.mem\[0\]\[39\] _1410_ VGND
+ VGND VPWR VPWR _1411_ sky130_fd_sc_hd__a221o_1
XFILLER_0_58_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3936_ net611 net71 _1917_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__mux2_1
X_3867_ net643 net35 _1882_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__mux2_1
X_3798_ _1847_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__clkbuf_1
X_2818_ net849 _1246_ _1024_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__mux2_1
X_2749_ net283 _1193_ _1194_ _1195_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4419_ clknet_leaf_56_clk _0255_ VGND VGND VPWR VPWR instance_1.rdata\[69\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_57_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 wdata[23] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_17_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4770_ clknet_leaf_60_clk _0606_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3721_ net897 net42 _1802_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3652_ _1767_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__clkbuf_1
X_2603_ _1042_ _1043_ instance_0.mem\[3\]\[8\] VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__and3_1
X_3583_ _1707_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__buf_2
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2534_ _1022_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2465_ _0985_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
X_2396_ net10 VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4204_ clknet_leaf_53_clk _0040_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_4135_ _2030_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__clkbuf_1
X_4066_ _1993_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__clkbuf_1
X_3017_ net297 _1388_ _1395_ _1397_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__o22a_1
XFILLER_0_19_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3919_ net644 net62 _1910_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2250_ net562 _0838_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_0_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2181_ _0794_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4822_ clknet_leaf_21_clk _0658_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_4753_ clknet_leaf_15_clk _0589_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3704_ net767 net33 _1795_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4684_ clknet_leaf_13_clk _0520_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_3635_ net557 _0919_ _1752_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3566_ net496 _0847_ _1715_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__mux2_1
X_2517_ _1013_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
X_3497_ _1682_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2448_ _0817_ net818 _0973_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__mux2_1
X_2379_ _0929_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_4118_ _2021_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_67_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4049_ _1984_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_18_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold8 _0242_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold408 instance_1.mem\[1\]\[65\] VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold419 instance_1.mem\[3\]\[16\] VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3420_ _0860_ net798 _1635_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3351_ _1602_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2302_ net58 VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__dlymetal6s2s_1
X_3282_ _1564_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2233_ net34 VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_88_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2164_ instance_0.rdata\[53\] instance_1.rdata\[53\] _0779_ VGND VGND VPWR VPWR _0785_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2095_ _0747_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4805_ clknet_leaf_37_clk _0641_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2997_ instance_1.mem\[0\]\[31\] instance_1.mem\[1\]\[31\] instance_1.mem\[2\]\[31\]
+ instance_1.mem\[3\]\[31\] _1335_ _1375_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__mux4_1
X_4736_ clknet_leaf_31_clk _0572_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4667_ clknet_leaf_30_clk _0503_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3618_ net932 _0900_ _1743_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__mux2_1
X_4598_ clknet_leaf_23_clk _0434_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_3549_ net397 _0830_ _1708_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2920_ instance_1.mem\[0\]\[11\] _1276_ _1268_ instance_1.mem\[2\]\[11\] VGND VGND
+ VPWR VPWR _1325_ sky130_fd_sc_hd__a22o_1
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2851_ net319 _1248_ _1269_ _1271_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__o22a_1
X_2782_ net163 _1193_ _1219_ _1220_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__o22a_1
X_4521_ clknet_leaf_29_clk _0357_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_4452_ clknet_leaf_24_clk _0288_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
Xhold205 instance_1.rdata\[59\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold216 _0135_ VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
Xhold249 instance_1.mem\[3\]\[38\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlygate4sd3_1
Xhold238 instance_1.mem\[2\]\[10\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__dlygate4sd3_1
Xhold227 instance_1.mem\[1\]\[40\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlygate4sd3_1
X_3403_ _0843_ net811 _1628_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__mux2_1
X_4383_ clknet_leaf_27_clk net250 VGND VGND VPWR VPWR instance_1.rdata\[33\] sky130_fd_sc_hd__dfxtp_1
X_3334_ _1593_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__clkbuf_1
X_3265_ _1533_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__clkbuf_4
X_2216_ _0816_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_49_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3196_ _1517_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
X_2147_ instance_0.rdata\[45\] instance_1.rdata\[45\] _0772_ VGND VGND VPWR VPWR _0776_
+ sky130_fd_sc_hd__mux2_1
X_2078_ _0738_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4719_ clknet_leaf_47_clk _0555_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold750 instance_1.mem\[0\]\[38\] VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__dlygate4sd3_1
Xhold761 instance_1.mem\[0\]\[7\] VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__dlygate4sd3_1
Xhold772 instance_0.mem\[3\]\[64\] VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__dlygate4sd3_1
Xhold794 instance_0.mem\[2\]\[28\] VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__dlygate4sd3_1
Xhold783 instance_0.mem\[1\]\[1\] VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_75_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3050_ instance_1.mem\[0\]\[44\] _1371_ _1394_ instance_1.mem\[3\]\[44\] VGND VGND
+ VPWR VPWR _1422_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3952_ _1931_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__clkbuf_1
X_3883_ _1893_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__clkbuf_1
X_2903_ instance_1.mem\[1\]\[7\] _1272_ _1311_ instance_1.mem\[3\]\[7\] VGND VGND
+ VPWR VPWR _1312_ sky130_fd_sc_hd__a22o_1
X_2834_ _1256_ _1257_ _1258_ _1025_ net151 VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__o32a_1
XFILLER_0_60_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2765_ _1207_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
X_4504_ clknet_leaf_46_clk _0340_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2696_ net211 _1149_ _1154_ _1155_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__o22a_1
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4435_ clknet_leaf_39_clk _0271_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4366_ clknet_leaf_40_clk net218 VGND VGND VPWR VPWR instance_1.rdata\[16\] sky130_fd_sc_hd__dfxtp_1
X_3317_ _0919_ net743 _1578_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__mux2_1
X_4297_ clknet_leaf_32_clk _0133_ VGND VGND VPWR VPWR instance_0.rdata\[19\] sky130_fd_sc_hd__dfxtp_1
X_3248_ _0847_ net590 _1541_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3179_ _1508_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_80_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold580 instance_1.mem\[0\]\[55\] VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dlygate4sd3_1
Xhold591 instance_0.mem\[1\]\[39\] VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput107 net107 VGND VGND VPWR VPWR rdata[37] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2550_ _0906_ net2 VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__and2b_1
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput118 net118 VGND VGND VPWR VPWR rdata[47] sky130_fd_sc_hd__clkbuf_4
X_2481_ _0849_ net463 _0988_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__mux2_1
Xoutput129 net129 VGND VGND VPWR VPWR rdata[57] sky130_fd_sc_hd__clkbuf_4
X_4220_ clknet_leaf_42_clk _0056_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_91_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4151_ _0891_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__buf_2
X_4082_ _0886_ net759 _1997_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__mux2_1
X_3102_ instance_1.mem\[3\]\[58\] _1090_ _1437_ instance_1.mem\[2\]\[58\] VGND VGND
+ VPWR VPWR _1460_ sky130_fd_sc_hd__a22o_1
X_3033_ _1297_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_77_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3935_ _1921_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3866_ _1884_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3797_ net445 net70 _1846_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2817_ instance_0.mem\[0\]\[59\] instance_0.mem\[1\]\[59\] instance_0.mem\[2\]\[59\]
+ instance_0.mem\[3\]\[59\] _1186_ _1205_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__mux4_1
X_2748_ instance_0.mem\[0\]\[41\] _1144_ _1182_ instance_0.mem\[2\]\[41\] _1179_ VGND
+ VGND VPWR VPWR _1195_ sky130_fd_sc_hd__a221o_1
X_4418_ clknet_leaf_53_clk net290 VGND VGND VPWR VPWR instance_1.rdata\[68\] sky130_fd_sc_hd__dfxtp_1
X_2679_ net179 _1131_ _1139_ _1142_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__o22a_1
X_4349_ clknet_leaf_55_clk net328 VGND VGND VPWR VPWR instance_0.rdata\[71\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_57_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_28_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3720_ _1804_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_40_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_40_clk sky130_fd_sc_hd__clkbuf_8
X_3651_ net418 _0934_ _1766_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__mux2_1
X_2602_ instance_0.mem\[0\]\[8\] _1053_ _1031_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__a21o_1
X_3582_ _1728_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2533_ _0902_ net884 _1016_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2464_ _0832_ net674 _0981_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__mux2_1
X_4203_ clknet_leaf_56_clk _0039_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_2395_ _0940_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
X_4134_ net795 net11 _2025_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__mux2_1
X_4065_ _0869_ net631 _1990_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__mux2_1
X_3016_ instance_1.mem\[0\]\[35\] _1339_ _1396_ instance_1.mem\[2\]\[35\] _1386_ VGND
+ VGND VPWR VPWR _1397_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_54_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3918_ _1912_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_31_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_31_clk sky130_fd_sc_hd__clkbuf_8
X_3849_ net572 net27 _1874_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_22_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_20_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2180_ instance_0.rdata\[60\] instance_1.rdata\[60\] _0793_ VGND VGND VPWR VPWR _0794_
+ sky130_fd_sc_hd__mux2_1
X_4821_ clknet_leaf_17_clk _0657_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4752_ clknet_leaf_17_clk _0588_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[42\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_13_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
X_4683_ clknet_leaf_14_clk _0519_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3703_ _1794_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__clkbuf_4
X_3634_ _1757_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_31_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3565_ _1719_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__clkbuf_1
X_2516_ _0884_ net614 _1009_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__mux2_1
X_3496_ net379 _0939_ _1679_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__mux2_1
X_2447_ _0975_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2378_ _0928_ net589 _0922_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__mux2_1
X_4117_ net694 net74 _2018_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_67_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4048_ _0851_ net763 _1983_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold9 instance_0.rdata\[12\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_287 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold409 instance_1.mem\[2\]\[5\] VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__dlygate4sd3_1
X_3350_ _0952_ net839 _1599_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2301_ _0874_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
X_3281_ _0880_ net646 _1562_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2232_ _0827_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_2_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_88_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2163_ _0784_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_64_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2094_ instance_0.rdata\[21\] instance_1.rdata\[21\] _0743_ VGND VGND VPWR VPWR _0747_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4804_ clknet_leaf_34_clk _0640_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2996_ net347 _1366_ _1380_ _1381_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__o22a_1
XFILLER_0_28_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4735_ clknet_leaf_31_clk _0571_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4666_ clknet_leaf_28_clk _0502_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3617_ _1747_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__clkbuf_1
X_4597_ clknet_leaf_23_clk _0433_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_3548_ _1710_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__clkbuf_1
X_3479_ net458 _0921_ _1672_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2850_ instance_0.mem\[0\]\[67\] _1270_ _1108_ instance_0.mem\[3\]\[67\] _1266_ VGND
+ VGND VPWR VPWR _1271_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2781_ instance_0.mem\[0\]\[49\] _1202_ _1182_ instance_0.mem\[2\]\[49\] _1203_ VGND
+ VGND VPWR VPWR _1220_ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4520_ clknet_leaf_31_clk _0356_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold217 instance_1.rdata\[41\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
X_4451_ clknet_leaf_29_clk _0287_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
Xhold206 _0245_ VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
X_3402_ _1630_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold228 instance_0.mem\[3\]\[12\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlygate4sd3_1
Xhold239 instance_1.mem\[3\]\[5\] VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__dlygate4sd3_1
X_4382_ clknet_leaf_23_clk net336 VGND VGND VPWR VPWR instance_1.rdata\[32\] sky130_fd_sc_hd__dfxtp_1
X_3333_ _0934_ net619 _1592_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3264_ _1554_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__clkbuf_1
X_2215_ net392 _0815_ _0813_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__mux2_1
X_3195_ _0956_ net654 _1512_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2146_ _0775_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_1
X_2077_ instance_0.rdata\[13\] instance_1.rdata\[13\] _0736_ VGND VGND VPWR VPWR _0738_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2979_ instance_1.mem\[3\]\[26\] _1320_ _1329_ instance_1.mem\[2\]\[26\] VGND VGND
+ VPWR VPWR _1369_ sky130_fd_sc_hd__a22o_1
X_4718_ clknet_leaf_51_clk _0554_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4649_ clknet_leaf_43_clk _0485_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold751 instance_0.mem\[1\]\[2\] VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__dlygate4sd3_1
Xhold773 instance_0.mem\[1\]\[13\] VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__dlygate4sd3_1
Xhold740 instance_0.mem\[1\]\[23\] VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__dlygate4sd3_1
Xhold762 instance_0.mem\[2\]\[48\] VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__dlygate4sd3_1
Xhold795 instance_1.mem\[1\]\[34\] VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__dlygate4sd3_1
Xhold784 instance_1.mem\[3\]\[70\] VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_55_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_82_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3951_ _0917_ net765 _1926_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__mux2_1
X_2902_ _1093_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__clkbuf_4
X_3882_ net396 net43 _1889_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2833_ instance_0.mem\[3\]\[63\] _1090_ _1050_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__a21o_1
X_2764_ net415 _1206_ _1111_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4503_ clknet_leaf_46_clk _0339_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_91_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2695_ instance_0.mem\[0\]\[28\] _1144_ _1135_ instance_0.mem\[2\]\[28\] _1151_ VGND
+ VGND VPWR VPWR _1155_ sky130_fd_sc_hd__a221o_1
X_4434_ clknet_leaf_39_clk _0270_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4365_ clknet_leaf_44_clk _0201_ VGND VGND VPWR VPWR instance_1.rdata\[15\] sky130_fd_sc_hd__dfxtp_1
X_3316_ _1583_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4296_ clknet_leaf_38_clk net216 VGND VGND VPWR VPWR instance_0.rdata\[18\] sky130_fd_sc_hd__dfxtp_1
X_3247_ _1545_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_1
X_3178_ _0939_ net624 _1505_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__mux2_1
X_2129_ _0766_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_80_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold570 instance_1.mem\[1\]\[43\] VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dlygate4sd3_1
Xhold581 instance_0.mem\[3\]\[23\] VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__dlygate4sd3_1
Xhold592 instance_1.mem\[2\]\[70\] VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput108 net108 VGND VGND VPWR VPWR rdata[38] sky130_fd_sc_hd__clkbuf_4
Xoutput119 net119 VGND VGND VPWR VPWR rdata[48] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2480_ _0993_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_91_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4150_ _2038_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__clkbuf_1
X_3101_ net251 _1454_ _1458_ _1459_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__o22a_1
Xoutput90 net90 VGND VGND VPWR VPWR rdata[21] sky130_fd_sc_hd__clkbuf_4
X_4081_ _2001_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__clkbuf_1
X_3032_ instance_1.mem\[3\]\[39\] _1389_ _1408_ instance_1.mem\[2\]\[39\] VGND VGND
+ VPWR VPWR _1409_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3934_ net979 net69 _1917_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__mux2_1
X_3865_ net905 net34 _1882_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2816_ net167 _1227_ _1244_ _1245_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__o22a_1
XFILLER_0_5_132 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3796_ _1838_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__buf_2
X_2747_ instance_0.mem\[1\]\[41\] _1146_ _1153_ instance_0.mem\[3\]\[41\] VGND VGND
+ VPWR VPWR _1194_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2678_ instance_0.mem\[1\]\[24\] _1140_ _1123_ instance_0.mem\[0\]\[24\] _1141_ VGND
+ VGND VPWR VPWR _1142_ sky130_fd_sc_hd__a221o_1
X_4417_ clknet_leaf_57_clk _0253_ VGND VGND VPWR VPWR instance_1.rdata\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4348_ clknet_leaf_53_clk net260 VGND VGND VPWR VPWR instance_0.rdata\[70\] sky130_fd_sc_hd__dfxtp_1
X_4279_ clknet_leaf_48_clk net236 VGND VGND VPWR VPWR instance_0.rdata\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_57_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3650_ _1751_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__clkbuf_4
X_2601_ net189 _1075_ _1079_ _1081_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__o22a_1
X_3581_ net507 _0862_ _1722_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__mux2_1
X_2532_ _1021_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2463_ _0984_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
X_4202_ clknet_leaf_53_clk _0038_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_2394_ _0939_ net688 _0935_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__mux2_1
X_4133_ _2029_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4064_ _1992_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__clkbuf_1
X_3015_ _1098_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_54_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3917_ net479 net61 _1910_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__mux2_1
X_3848_ _1838_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__buf_2
X_3779_ net459 net72 _1830_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4820_ clknet_leaf_26_clk _0656_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_4751_ clknet_leaf_19_clk _0587_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_4682_ clknet_leaf_14_clk _0518_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_3702_ _1750_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__buf_2
X_3633_ net467 _0917_ _1752_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3564_ net476 _0845_ _1715_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2515_ _1012_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
X_3495_ _1681_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2446_ _0815_ net908 _0973_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__mux2_1
X_2377_ net75 VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4116_ _2020_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_67_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4047_ _1968_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__buf_2
XFILLER_0_38_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3280_ _1563_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2300_ net560 _0873_ _0865_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__mux2_1
X_2231_ net695 _0825_ _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__mux2_1
X_2162_ instance_0.rdata\[52\] instance_1.rdata\[52\] _0779_ VGND VGND VPWR VPWR _0784_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2093_ _0746_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_64_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4803_ clknet_leaf_33_clk _0639_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_2995_ instance_1.mem\[0\]\[30\] _1339_ _1316_ instance_1.mem\[2\]\[30\] _1364_ VGND
+ VGND VPWR VPWR _1381_ sky130_fd_sc_hd__a221o_1
XFILLER_0_16_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4734_ clknet_leaf_35_clk _0570_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4665_ clknet_leaf_30_clk _0501_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_4596_ clknet_leaf_25_clk _0432_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3616_ net538 _0898_ _1743_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3547_ net377 _0828_ _1708_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3478_ _1664_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__clkbuf_4
X_2429_ _0963_ net855 _0961_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2780_ instance_0.mem\[1\]\[49\] _1218_ _1200_ instance_0.mem\[3\]\[49\] VGND VGND
+ VPWR VPWR _1219_ sky130_fd_sc_hd__a22o_1
Xhold207 instance_1.rdata\[39\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
X_4450_ clknet_leaf_28_clk _0286_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3401_ _0841_ net755 _1628_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__mux2_1
Xhold218 _0227_ VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
Xhold229 instance_1.mem\[3\]\[37\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__dlygate4sd3_1
X_4381_ clknet_leaf_23_clk _0217_ VGND VGND VPWR VPWR instance_1.rdata\[31\] sky130_fd_sc_hd__dfxtp_1
X_3332_ _1577_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__buf_2
X_3263_ _0862_ net879 _1548_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__mux2_1
X_3194_ _1516_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
X_2214_ net28 VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_56_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2145_ instance_0.rdata\[44\] instance_1.rdata\[44\] _0772_ VGND VGND VPWR VPWR _0775_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2076_ _0737_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2978_ net321 _1366_ _1367_ _1368_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__o22a_1
X_4717_ clknet_leaf_51_clk _0553_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4648_ clknet_leaf_46_clk _0484_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold730 instance_0.mem\[3\]\[47\] VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold763 instance_1.mem\[0\]\[36\] VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__dlygate4sd3_1
Xhold741 instance_0.mem\[0\]\[13\] VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__dlygate4sd3_1
X_4579_ clknet_leaf_41_clk _0415_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold752 instance_0.mem\[0\]\[53\] VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__dlygate4sd3_1
Xhold796 instance_0.mem\[3\]\[67\] VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__dlygate4sd3_1
Xhold785 instance_0.mem\[1\]\[67\] VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__dlygate4sd3_1
Xhold774 instance_0.mem\[0\]\[8\] VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_4_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold90 _0190_ VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3950_ _1930_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__clkbuf_1
X_2901_ _1310_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3881_ _1892_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__clkbuf_1
X_2832_ instance_0.mem\[1\]\[63\] _1027_ _1037_ instance_0.mem\[0\]\[63\] VGND VGND
+ VPWR VPWR _1257_ sky130_fd_sc_hd__a22o_1
X_2763_ instance_0.mem\[0\]\[45\] instance_0.mem\[1\]\[45\] instance_0.mem\[2\]\[45\]
+ instance_0.mem\[3\]\[45\] _1186_ _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__mux4_1
XFILLER_0_5_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4502_ clknet_leaf_51_clk _0338_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_2694_ instance_0.mem\[1\]\[28\] _1146_ _1153_ instance_0.mem\[3\]\[28\] VGND VGND
+ VPWR VPWR _1154_ sky130_fd_sc_hd__a22o_1
X_4433_ clknet_leaf_51_clk _0269_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4364_ clknet_leaf_42_clk _0200_ VGND VGND VPWR VPWR instance_1.rdata\[14\] sky130_fd_sc_hd__dfxtp_1
X_3315_ _0917_ net826 _1578_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__mux2_1
X_4295_ clknet_leaf_41_clk net330 VGND VGND VPWR VPWR instance_0.rdata\[17\] sky130_fd_sc_hd__dfxtp_1
X_3246_ _0845_ net734 _1541_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3177_ _1507_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
X_2128_ instance_0.rdata\[36\] instance_1.rdata\[36\] _0765_ VGND VGND VPWR VPWR _0766_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2059_ instance_0.rdata\[5\] instance_1.rdata\[5\] _0722_ VGND VGND VPWR VPWR _0728_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_80_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold571 instance_1.mem\[0\]\[69\] VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dlygate4sd3_1
Xhold560 instance_0.mem\[3\]\[48\] VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__dlygate4sd3_1
Xhold593 instance_0.mem\[0\]\[18\] VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__dlygate4sd3_1
Xhold582 instance_1.mem\[1\]\[23\] VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput109 net109 VGND VGND VPWR VPWR rdata[39] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput80 net80 VGND VGND VPWR VPWR rdata[12] sky130_fd_sc_hd__clkbuf_4
X_3100_ instance_1.mem\[1\]\[57\] _1225_ _1405_ instance_1.mem\[0\]\[57\] _1456_ VGND
+ VGND VPWR VPWR _1459_ sky130_fd_sc_hd__a221o_1
Xoutput91 net91 VGND VGND VPWR VPWR rdata[22] sky130_fd_sc_hd__clkbuf_4
X_4080_ _0884_ net515 _1997_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3031_ _1039_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__buf_2
XFILLER_0_53_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3933_ _1920_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3864_ _1883_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2815_ instance_0.mem\[1\]\[58\] _1215_ _1108_ instance_0.mem\[3\]\[58\] _1242_ VGND
+ VGND VPWR VPWR _1245_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3795_ _1845_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__clkbuf_1
X_2746_ _1073_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__buf_2
XFILLER_0_14_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2677_ _1042_ _1043_ instance_0.mem\[3\]\[24\] VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__and3_1
X_4416_ clknet_leaf_54_clk net352 VGND VGND VPWR VPWR instance_1.rdata\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4347_ clknet_leaf_55_clk net280 VGND VGND VPWR VPWR instance_0.rdata\[69\] sky130_fd_sc_hd__dfxtp_1
X_4278_ clknet_leaf_49_clk net198 VGND VGND VPWR VPWR instance_0.rdata\[0\] sky130_fd_sc_hd__dfxtp_1
X_3229_ _0828_ net962 _1534_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold390 instance_1.mem\[3\]\[69\] VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2600_ instance_0.mem\[0\]\[7\] _1067_ _1080_ instance_0.mem\[2\]\[7\] _1057_ VGND
+ VGND VPWR VPWR _1081_ sky130_fd_sc_hd__a221o_1
X_3580_ _1727_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__clkbuf_1
X_2531_ _0900_ net975 _1016_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2462_ _0830_ net585 _0981_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__mux2_1
X_4201_ clknet_leaf_57_clk _0037_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_2393_ net9 VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4132_ net462 net10 _2025_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__mux2_1
X_4063_ _0867_ net728 _1990_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__mux2_1
X_3014_ instance_1.mem\[1\]\[35\] _1362_ _1394_ instance_1.mem\[3\]\[35\] VGND VGND
+ VPWR VPWR _1395_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3916_ _1911_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_62_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3847_ _1873_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__clkbuf_1
X_3778_ _1835_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__clkbuf_1
X_2729_ net263 _1171_ _1178_ _1180_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4750_ clknet_leaf_21_clk _0586_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_4681_ clknet_leaf_15_clk _0517_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_3701_ _1793_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3632_ _1756_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3563_ _1718_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__clkbuf_1
X_2514_ _0882_ net941 _1009_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__mux2_1
X_3494_ net616 _0937_ _1679_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__mux2_1
X_2445_ _0974_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4115_ net822 net73 _2018_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__mux2_1
X_2376_ _0927_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_67_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4046_ _1982_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_39_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4879_ clknet_leaf_31_clk _0715_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_4_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2230_ _0812_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__buf_2
X_2161_ _0783_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_88_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2092_ instance_0.rdata\[20\] instance_1.rdata\[20\] _0743_ VGND VGND VPWR VPWR _0746_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_64_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2994_ instance_1.mem\[1\]\[30\] _1362_ _1311_ instance_1.mem\[3\]\[30\] VGND VGND
+ VPWR VPWR _1380_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_72_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4802_ clknet_leaf_22_clk _0638_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_4733_ clknet_leaf_36_clk _0569_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_123 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4664_ clknet_leaf_32_clk _0500_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4595_ clknet_leaf_30_clk _0431_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_3615_ _1746_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__clkbuf_1
X_3546_ _1709_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__clkbuf_1
X_3477_ _1671_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__clkbuf_1
X_2428_ net21 VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__dlymetal6s2s_1
X_2359_ _0915_ net652 _0909_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__mux2_1
X_4029_ _1973_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold208 _0225_ VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
X_3400_ _1629_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__clkbuf_1
Xhold219 instance_0.rdata\[27\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
X_4380_ clknet_leaf_25_clk net348 VGND VGND VPWR VPWR instance_1.rdata\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3331_ _1591_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3262_ _1553_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__clkbuf_1
X_2213_ _0814_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
X_3193_ _0954_ net660 _1512_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2144_ _0774_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_49_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2075_ instance_0.rdata\[12\] instance_1.rdata\[12\] _0736_ VGND VGND VPWR VPWR _0737_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2977_ instance_1.mem\[1\]\[25\] _1349_ _1350_ instance_1.mem\[0\]\[25\] _1364_ VGND
+ VGND VPWR VPWR _1368_ sky130_fd_sc_hd__a221o_1
XFILLER_0_8_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4716_ clknet_leaf_48_clk _0552_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4647_ clknet_leaf_43_clk _0483_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold720 instance_1.mem\[1\]\[5\] VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__dlygate4sd3_1
Xhold742 instance_0.mem\[0\]\[69\] VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__dlygate4sd3_1
X_4578_ clknet_leaf_39_clk _0414_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
Xhold753 instance_0.mem\[2\]\[59\] VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__dlygate4sd3_1
Xhold731 instance_0.mem\[1\]\[53\] VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__dlygate4sd3_1
Xhold764 instance_0.mem\[2\]\[19\] VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__dlygate4sd3_1
Xhold786 instance_0.mem\[0\]\[28\] VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__dlygate4sd3_1
X_3529_ _1699_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__clkbuf_1
Xhold775 instance_0.mem\[1\]\[71\] VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__dlygate4sd3_1
Xhold797 instance_1.mem\[1\]\[59\] VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_4_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold91 instance_1.rdata\[34\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
Xhold80 _0199_ VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2900_ net582 _1309_ _1288_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_18_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3880_ net517 net42 _1889_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__mux2_1
X_2831_ instance_0.mem\[2\]\[63\] _1099_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2762_ _1070_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__buf_4
X_4501_ clknet_leaf_51_clk _0337_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4432_ clknet_leaf_46_clk _0268_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_2693_ _1047_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__clkbuf_4
X_4363_ clknet_leaf_41_clk net228 VGND VGND VPWR VPWR instance_1.rdata\[13\] sky130_fd_sc_hd__dfxtp_1
X_3314_ _1582_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__clkbuf_1
X_4294_ clknet_leaf_40_clk net324 VGND VGND VPWR VPWR instance_0.rdata\[16\] sky130_fd_sc_hd__dfxtp_1
X_3245_ _1544_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3176_ _0937_ net921 _1505_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2127_ _0764_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__buf_2
X_2058_ _0727_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_80_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold550 instance_1.mem\[0\]\[33\] VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dlygate4sd3_1
Xhold561 instance_0.mem\[2\]\[38\] VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__dlygate4sd3_1
Xhold572 instance_0.mem\[2\]\[58\] VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__dlygate4sd3_1
Xhold583 instance_1.mem\[1\]\[3\] VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__dlygate4sd3_1
Xhold594 instance_1.mem\[0\]\[1\] VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_52_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_52_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput81 net81 VGND VGND VPWR VPWR rdata[13] sky130_fd_sc_hd__clkbuf_4
Xoutput92 net92 VGND VGND VPWR VPWR rdata[23] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3030_ _1346_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__buf_2
XFILLER_0_58_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_43_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_43_clk sky130_fd_sc_hd__clkbuf_8
X_3932_ net468 net68 _1917_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3863_ net815 net33 _1882_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2814_ instance_0.mem\[0\]\[58\] _1189_ _1190_ instance_0.mem\[2\]\[58\] VGND VGND
+ VPWR VPWR _1244_ sky130_fd_sc_hd__a22o_1
X_3794_ net745 net59 _1839_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2745_ net287 _1171_ _1191_ _1192_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__o22a_1
XFILLER_0_78_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2676_ _1055_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__buf_2
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4415_ clknet_leaf_59_clk _0251_ VGND VGND VPWR VPWR instance_1.rdata\[65\] sky130_fd_sc_hd__dfxtp_1
X_4346_ clknet_leaf_53_clk net232 VGND VGND VPWR VPWR instance_0.rdata\[68\] sky130_fd_sc_hd__dfxtp_1
X_4277_ clknet_leaf_55_clk _0113_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_3228_ _1535_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
X_3159_ _1497_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_57_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_34_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_34_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_91_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold380 instance_1.mem\[2\]\[58\] VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__dlygate4sd3_1
Xhold391 instance_1.mem\[2\]\[69\] VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_25_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2530_ _1020_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2461_ _0983_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
X_4200_ clknet_leaf_4_clk _0036_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_2392_ _0938_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_79_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4131_ _2028_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__clkbuf_1
X_4062_ _1991_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3013_ _1093_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_54_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_16_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_19_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_88_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3915_ net497 net60 _1910_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3846_ net642 net25 _1867_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3777_ net740 net71 _1830_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__mux2_1
X_2728_ instance_0.mem\[1\]\[36\] _1173_ _1169_ instance_0.mem\[0\]\[36\] _1179_ VGND
+ VGND VPWR VPWR _1180_ sky130_fd_sc_hd__a221o_1
X_2659_ _1087_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__buf_2
XFILLER_0_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4329_ clknet_leaf_8_clk net154 VGND VGND VPWR VPWR instance_0.rdata\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3700_ net867 net32 _1787_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4680_ clknet_leaf_15_clk _0516_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3631_ net669 _0915_ _1752_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__mux2_1
X_3562_ net574 _0843_ _1715_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2513_ _1011_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3493_ _1680_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2444_ _0807_ net842 _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_5_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
X_2375_ _0926_ net922 _0922_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__mux2_1
X_4114_ _2019_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_67_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4045_ _0849_ net819 _1976_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4878_ clknet_leaf_24_clk _0714_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3829_ net444 net17 _1860_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_30_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2160_ instance_0.rdata\[51\] instance_1.rdata\[51\] _0779_ VGND VGND VPWR VPWR _0783_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2091_ _0745_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2993_ net317 _1366_ _1378_ _1379_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_72_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4801_ clknet_leaf_33_clk _0637_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4732_ clknet_leaf_34_clk _0568_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_83_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4663_ clknet_leaf_32_clk _0499_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_3614_ net406 _0896_ _1743_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__mux2_1
X_4594_ clknet_leaf_28_clk _0430_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_3545_ net766 _0825_ _1708_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3476_ net387 _0919_ _1665_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2427_ _0962_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2358_ net37 VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_79_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2289_ _0866_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
X_4028_ _0832_ net929 _1969_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold209 instance_1.rdata\[7\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
X_3330_ _0932_ net605 _1585_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__mux2_1
X_3261_ _0860_ net770 _1548_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__mux2_1
X_2212_ net809 _0807_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__mux2_1
X_3192_ _1515_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
X_2143_ instance_0.rdata\[43\] instance_1.rdata\[43\] _0772_ VGND VGND VPWR VPWR _0774_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2074_ _0721_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__buf_2
XFILLER_0_76_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2976_ instance_1.mem\[3\]\[25\] _1320_ _1329_ instance_1.mem\[2\]\[25\] VGND VGND
+ VPWR VPWR _1367_ sky130_fd_sc_hd__a22o_1
X_4715_ clknet_leaf_52_clk _0551_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_15_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4646_ clknet_leaf_38_clk _0482_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold721 instance_0.mem\[3\]\[3\] VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__dlygate4sd3_1
X_4577_ clknet_leaf_47_clk _0413_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
Xhold710 instance_0.mem\[2\]\[8\] VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlygate4sd3_1
Xhold754 instance_0.mem\[0\]\[34\] VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__dlygate4sd3_1
Xhold732 instance_0.mem\[0\]\[0\] VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__dlygate4sd3_1
Xhold743 instance_0.mem\[2\]\[49\] VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__dlygate4sd3_1
X_3528_ net612 _0971_ _1693_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__mux2_1
Xhold776 instance_1.mem\[0\]\[57\] VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__dlygate4sd3_1
Xhold765 instance_0.mem\[1\]\[49\] VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__dlygate4sd3_1
Xhold787 instance_0.mem\[2\]\[40\] VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__dlygate4sd3_1
X_3459_ _0900_ net980 _1656_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__mux2_1
Xhold798 instance_0.mem\[1\]\[11\] VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_4_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_42_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold92 _0220_ VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 instance_0.rdata\[5\] VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 _0202_ VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_85_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2830_ net275 _1248_ _1254_ _1255_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_51_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2761_ net241 _1193_ _1201_ _1204_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__o22a_1
X_2692_ net367 _1149_ _1150_ _1152_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__o22a_1
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4500_ clknet_leaf_48_clk _0336_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4431_ clknet_leaf_47_clk _0267_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_1 _1043_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4362_ clknet_leaf_39_clk net202 VGND VGND VPWR VPWR instance_1.rdata\[12\] sky130_fd_sc_hd__dfxtp_1
X_3313_ _0915_ net788 _1578_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__mux2_1
X_4293_ clknet_leaf_42_clk net220 VGND VGND VPWR VPWR instance_0.rdata\[15\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_60_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3244_ _0843_ net789 _1541_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3175_ _1506_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
X_2126_ _0720_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__clkbuf_2
X_2057_ instance_0.rdata\[4\] instance_1.rdata\[4\] _0722_ VGND VGND VPWR VPWR _0727_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_80_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2959_ net339 _1347_ _1353_ _1354_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__o22a_1
XFILLER_0_32_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4629_ clknet_leaf_59_clk _0465_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold540 instance_0.mem\[0\]\[14\] VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__dlygate4sd3_1
Xhold562 instance_0.mem\[0\]\[59\] VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlygate4sd3_1
Xhold551 instance_1.mem\[0\]\[5\] VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dlygate4sd3_1
Xhold573 instance_0.mem\[0\]\[6\] VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__dlygate4sd3_1
Xhold584 instance_1.mem\[2\]\[64\] VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__dlygate4sd3_1
Xhold595 instance_0.mem\[2\]\[5\] VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_91_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput93 net93 VGND VGND VPWR VPWR rdata[24] sky130_fd_sc_hd__clkbuf_4
Xoutput82 net82 VGND VGND VPWR VPWR rdata[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3931_ _1919_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3862_ _1881_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2813_ net193 _1227_ _1240_ _1243_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__o22a_1
X_3793_ _1844_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2744_ instance_0.mem\[1\]\[40\] _1173_ _1108_ instance_0.mem\[3\]\[40\] _1179_ VGND
+ VGND VPWR VPWR _1192_ sky130_fd_sc_hd__a221o_1
X_2675_ instance_0.mem\[2\]\[24\] _1100_ _1031_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__a21o_1
X_4414_ clknet_leaf_4_clk net270 VGND VGND VPWR VPWR instance_1.rdata\[64\] sky130_fd_sc_hd__dfxtp_1
X_4345_ clknet_leaf_57_clk net320 VGND VGND VPWR VPWR instance_0.rdata\[67\] sky130_fd_sc_hd__dfxtp_1
X_4276_ clknet_leaf_55_clk _0112_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_3227_ _0825_ net916 _1534_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__mux2_1
X_3158_ _0919_ net778 _1491_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__mux2_1
X_2109_ instance_0.rdata\[28\] instance_1.rdata\[28\] _0750_ VGND VGND VPWR VPWR _0755_
+ sky130_fd_sc_hd__mux2_1
X_3089_ instance_1.mem\[0\]\[54\] _1401_ _1450_ instance_1.mem\[2\]\[54\] _1433_ VGND
+ VGND VPWR VPWR _1451_ sky130_fd_sc_hd__a221o_1
XFILLER_0_76_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_474 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold381 instance_1.mem\[3\]\[4\] VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__dlygate4sd3_1
Xhold370 instance_1.mem\[3\]\[32\] VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__dlygate4sd3_1
Xhold392 instance_1.rdata\[1\] VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2460_ _0828_ net966 _0981_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__mux2_1
X_4130_ net417 net9 _2025_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__mux2_1
X_2391_ _0937_ net889 _0935_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4061_ _0864_ net726 _1990_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__mux2_1
X_3012_ net239 _1388_ _1392_ _1393_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__o22a_1
XFILLER_0_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3914_ _1881_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__buf_2
XFILLER_0_46_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3845_ _1872_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__clkbuf_1
X_3776_ _1834_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2727_ _1029_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__buf_2
XFILLER_0_73_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2658_ _1126_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2589_ _1070_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__buf_4
X_4328_ clknet_leaf_11_clk _0164_ VGND VGND VPWR VPWR instance_0.rdata\[50\] sky130_fd_sc_hd__dfxtp_1
X_4259_ clknet_leaf_10_clk _0095_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3630_ _1755_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__clkbuf_1
X_3561_ _1717_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2512_ _0880_ net544 _1009_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3492_ net602 _0934_ _1679_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2443_ _0908_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__buf_2
X_2374_ net74 VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__dlymetal6s2s_1
X_4113_ net411 net70 _2018_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4044_ _1981_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4877_ clknet_leaf_36_clk _0713_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_3828_ _1863_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3759_ _1825_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_69_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2090_ instance_0.rdata\[19\] instance_1.rdata\[19\] _0743_ VGND VGND VPWR VPWR _0745_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_64_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4800_ clknet_leaf_36_clk _0636_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_2992_ instance_1.mem\[1\]\[29\] _1349_ _1350_ instance_1.mem\[0\]\[29\] _1364_ VGND
+ VGND VPWR VPWR _1379_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_72_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4731_ clknet_leaf_34_clk _0567_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4662_ clknet_leaf_31_clk _0498_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3613_ _1745_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__clkbuf_1
X_4593_ clknet_leaf_30_clk _0429_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3544_ _1707_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__clkbuf_4
X_3475_ _1670_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2426_ _0960_ net626 _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__mux2_1
X_2357_ _0914_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_2288_ net592 _0864_ _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__mux2_1
X_4027_ _1972_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_41_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3260_ _1552_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3191_ _0952_ net887 _1512_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__mux2_1
X_2211_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__buf_2
X_2142_ _0773_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_77_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2073_ _0735_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_49_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4714_ clknet_leaf_52_clk _0550_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2975_ _1346_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__buf_2
XFILLER_0_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4645_ clknet_leaf_51_clk _0481_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold711 instance_0.mem\[2\]\[67\] VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dlygate4sd3_1
X_4576_ clknet_leaf_46_clk _0412_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
Xhold700 instance_1.mem\[0\]\[31\] VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlygate4sd3_1
Xhold733 instance_0.mem\[1\]\[42\] VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__dlygate4sd3_1
X_3527_ _1698_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__clkbuf_1
Xhold722 instance_0.mem\[2\]\[16\] VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__dlygate4sd3_1
Xhold755 instance_0.mem\[2\]\[22\] VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__dlygate4sd3_1
Xhold744 instance_0.mem\[2\]\[50\] VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__dlygate4sd3_1
Xhold777 instance_0.mem\[1\]\[16\] VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__dlygate4sd3_1
Xhold766 instance_0.mem\[2\]\[18\] VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__dlygate4sd3_1
Xhold788 instance_0.mem\[3\]\[53\] VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__dlygate4sd3_1
X_3458_ _1660_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__clkbuf_1
Xhold799 instance_1.mem\[2\]\[55\] VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__dlygate4sd3_1
X_2409_ net14 VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__dlymetal6s2s_1
X_3389_ _1623_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_4_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_275 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold60 _0178_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold82 _0119_ VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 instance_0.rdata\[15\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_85_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold93 instance_0.rdata\[44\] VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2760_ instance_0.mem\[0\]\[44\] _1202_ _1182_ instance_0.mem\[2\]\[44\] _1203_ VGND
+ VGND VPWR VPWR _1204_ sky130_fd_sc_hd__a221o_1
X_2691_ instance_0.mem\[1\]\[27\] _1140_ _1123_ instance_0.mem\[0\]\[27\] _1151_ VGND
+ VGND VPWR VPWR _1152_ sky130_fd_sc_hd__a221o_1
XFILLER_0_53_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4430_ clknet_leaf_51_clk _0266_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_2 _1108_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4361_ clknet_leaf_43_clk net326 VGND VGND VPWR VPWR instance_1.rdata\[11\] sky130_fd_sc_hd__dfxtp_1
X_4292_ clknet_leaf_42_clk _0128_ VGND VGND VPWR VPWR instance_0.rdata\[14\] sky130_fd_sc_hd__dfxtp_1
X_3312_ _1581_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3243_ _1543_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3174_ _0934_ net672 _1505_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__mux2_1
X_2125_ _0763_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
X_2056_ _0726_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_80_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2958_ instance_1.mem\[2\]\[20\] _1100_ _1298_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__a21o_1
X_4628_ clknet_leaf_59_clk _0464_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_2889_ _1301_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__buf_2
Xhold530 instance_0.mem\[2\]\[26\] VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__dlygate4sd3_1
Xhold563 instance_0.mem\[3\]\[26\] VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__dlygate4sd3_1
Xhold541 instance_1.mem\[0\]\[3\] VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__dlygate4sd3_1
Xhold552 instance_0.mem\[1\]\[10\] VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__dlygate4sd3_1
X_4559_ clknet_leaf_58_clk _0395_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[65\] sky130_fd_sc_hd__dfxtp_1
Xhold585 instance_0.mem\[3\]\[27\] VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__dlygate4sd3_1
Xhold596 instance_1.rdata\[18\] VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__dlygate4sd3_1
Xhold574 instance_1.mem\[3\]\[49\] VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput83 net83 VGND VGND VPWR VPWR rdata[15] sky130_fd_sc_hd__buf_2
Xoutput94 net94 VGND VGND VPWR VPWR rdata[25] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3930_ net944 net67 _1917_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3861_ _1837_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__buf_2
XFILLER_0_58_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3792_ net838 net48 _1839_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__mux2_1
X_2812_ instance_0.mem\[1\]\[57\] _1215_ _1241_ instance_0.mem\[0\]\[57\] _1242_ VGND
+ VGND VPWR VPWR _1243_ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2743_ instance_0.mem\[0\]\[40\] _1189_ _1190_ instance_0.mem\[2\]\[40\] VGND VGND
+ VPWR VPWR _1191_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2674_ net225 _1131_ _1137_ _1138_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__o22a_1
X_4413_ clknet_leaf_57_clk _0249_ VGND VGND VPWR VPWR instance_1.rdata\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_353 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4344_ clknet_leaf_54_clk net222 VGND VGND VPWR VPWR instance_0.rdata\[66\] sky130_fd_sc_hd__dfxtp_1
X_4275_ clknet_leaf_55_clk _0111_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_3226_ _1533_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__buf_2
X_3157_ _1496_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
X_2108_ _0754_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_1
X_3088_ _1098_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__buf_2
XFILLER_0_49_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold360 instance_1.rdata\[28\] VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__dlygate4sd3_1
Xhold371 instance_1.mem\[3\]\[27\] VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold382 instance_1.mem\[0\]\[29\] VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__dlygate4sd3_1
Xhold393 instance_1.rdata\[31\] VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2390_ net8 VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_48_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4060_ _1968_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__buf_2
X_3011_ instance_1.mem\[1\]\[34\] _1385_ _1350_ instance_1.mem\[0\]\[34\] _1386_ VGND
+ VGND VPWR VPWR _1393_ sky130_fd_sc_hd__a221o_1
XFILLER_0_80_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3913_ _1909_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__clkbuf_1
X_3844_ net450 net24 _1867_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3775_ net539 net69 _1830_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__mux2_1
X_2726_ instance_0.mem\[3\]\[36\] _1177_ _1127_ instance_0.mem\[2\]\[36\] VGND VGND
+ VPWR VPWR _1178_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2657_ net393 _1125_ _1111_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2588_ _1034_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__clkbuf_2
X_4327_ clknet_leaf_12_clk net164 VGND VGND VPWR VPWR instance_0.rdata\[49\] sky130_fd_sc_hd__dfxtp_1
X_4258_ clknet_leaf_10_clk _0094_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_3209_ _1524_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
X_4189_ clknet_leaf_2_clk _0025_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold190 _0256_ VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3560_ net635 _0841_ _1715_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2511_ _1010_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
X_3491_ _1664_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__clkbuf_4
X_2442_ _0972_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
X_2373_ _0925_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4112_ _0891_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__buf_2
XFILLER_0_75_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4043_ _0847_ net595 _1976_ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4876_ clknet_leaf_34_clk _0712_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3827_ net676 net16 _1860_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__mux2_1
X_3758_ net915 net61 _1823_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_30_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2709_ _1041_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__buf_2
X_3689_ _1751_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_38_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2991_ instance_1.mem\[3\]\[29\] _1320_ _1372_ instance_1.mem\[2\]\[29\] VGND VGND
+ VPWR VPWR _1378_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_72_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4730_ clknet_leaf_36_clk _0566_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4661_ clknet_leaf_22_clk _0497_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_3612_ net421 _0894_ _1743_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4592_ clknet_leaf_32_clk _0428_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3543_ _1663_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__buf_2
X_3474_ net529 _0917_ _1665_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2425_ _0908_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__buf_2
X_2356_ _0913_ net830 _0909_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__mux2_1
X_2287_ _0812_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__buf_2
X_4026_ _0830_ net898 _1969_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4859_ clknet_leaf_52_clk _0695_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2210_ _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__buf_2
X_3190_ _1514_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
X_2141_ instance_0.rdata\[42\] instance_1.rdata\[42\] _0772_ VGND VGND VPWR VPWR _0773_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_77_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2072_ instance_0.rdata\[11\] instance_1.rdata\[11\] _0729_ VGND VGND VPWR VPWR _0735_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2974_ net233 _1347_ _1363_ _1365_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__o22a_1
X_4713_ clknet_leaf_50_clk _0549_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4644_ clknet_leaf_48_clk _0480_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4575_ clknet_leaf_43_clk _0411_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
Xhold701 instance_0.rdata\[59\] VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlygate4sd3_1
Xhold712 instance_1.mem\[2\]\[21\] VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__dlygate4sd3_1
Xhold734 instance_1.mem\[0\]\[34\] VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__dlygate4sd3_1
X_3526_ net413 _0969_ _1693_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold745 instance_0.mem\[0\]\[12\] VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__dlygate4sd3_1
Xhold723 instance_1.mem\[2\]\[53\] VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__dlygate4sd3_1
Xhold778 instance_1.mem\[2\]\[43\] VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold767 instance_1.mem\[2\]\[61\] VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__dlygate4sd3_1
Xhold756 instance_1.mem\[0\]\[40\] VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__dlygate4sd3_1
Xhold789 instance_1.mem\[0\]\[30\] VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__dlygate4sd3_1
X_3457_ _0898_ net977 _1656_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__mux2_1
X_2408_ _0949_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
X_3388_ _0828_ net969 _1621_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2339_ net712 _0900_ _0892_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4009_ _1962_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_83_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold50 _0114_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 instance_1.rdata\[9\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 instance_0.rdata\[68\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 _0129_ VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_85_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold94 _0158_ VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_55_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_55_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_46_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2690_ _1030_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__clkbuf_2
XANTENNA_3 _1205_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4360_ clknet_leaf_46_clk _0196_ VGND VGND VPWR VPWR instance_1.rdata\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3311_ _0913_ net917 _1578_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__mux2_1
X_4291_ clknet_leaf_40_clk net370 VGND VGND VPWR VPWR instance_0.rdata\[13\] sky130_fd_sc_hd__dfxtp_1
X_3242_ _0841_ net477 _1541_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3173_ _1490_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__buf_2
X_2124_ instance_0.rdata\[35\] instance_1.rdata\[35\] _0757_ VGND VGND VPWR VPWR _0763_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_46_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_46_clk sky130_fd_sc_hd__clkbuf_8
X_2055_ instance_0.rdata\[3\] instance_1.rdata\[3\] _0722_ VGND VGND VPWR VPWR _0726_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2957_ instance_1.mem\[1\]\[20\] _1027_ _1037_ instance_1.mem\[0\]\[20\] _1352_ VGND
+ VGND VPWR VPWR _1353_ sky130_fd_sc_hd__a221o_1
XFILLER_0_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2888_ _1296_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__buf_2
X_4627_ clknet_leaf_1_clk _0463_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold520 instance_0.mem\[0\]\[66\] VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dlygate4sd3_1
X_4558_ clknet_leaf_0_clk _0394_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[64\] sky130_fd_sc_hd__dfxtp_1
Xhold531 instance_1.mem\[1\]\[20\] VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__dlygate4sd3_1
Xhold542 instance_1.mem\[1\]\[50\] VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dlygate4sd3_1
Xhold553 instance_1.mem\[2\]\[37\] VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlygate4sd3_1
Xhold586 instance_0.mem\[1\]\[45\] VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dlygate4sd3_1
X_4489_ clknet_leaf_55_clk _0325_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold575 instance_1.mem\[3\]\[59\] VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__dlygate4sd3_1
Xhold597 instance_0.mem\[3\]\[5\] VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dlygate4sd3_1
Xhold564 instance_1.mem\[1\]\[70\] VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dlygate4sd3_1
X_3509_ net383 _0952_ _1686_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_37_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_37_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_43_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput84 net84 VGND VGND VPWR VPWR rdata[16] sky130_fd_sc_hd__buf_2
Xoutput95 net95 VGND VGND VPWR VPWR rdata[26] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_28_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_28_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_53_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3860_ _1880_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3791_ _1843_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__clkbuf_1
X_2811_ _1029_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__buf_2
X_2742_ _1087_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_81_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4412_ clknet_leaf_59_clk _0248_ VGND VGND VPWR VPWR instance_1.rdata\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2673_ instance_0.mem\[1\]\[23\] _1106_ _1135_ instance_0.mem\[2\]\[23\] _1129_ VGND
+ VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a221o_1
XFILLER_0_22_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4343_ clknet_leaf_58_clk net162 VGND VGND VPWR VPWR instance_0.rdata\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4274_ clknet_leaf_55_clk _0110_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_3225_ _1489_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__buf_2
X_3156_ _0917_ net972 _1491_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__mux2_1
X_2107_ instance_0.rdata\[27\] instance_1.rdata\[27\] _0750_ VGND VGND VPWR VPWR _0754_
+ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_19_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_27_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3087_ instance_1.mem\[1\]\[54\] _1448_ _1394_ instance_1.mem\[3\]\[54\] VGND VGND
+ VPWR VPWR _1449_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3989_ _1951_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_20_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold361 instance_1.mem\[1\]\[4\] VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__dlygate4sd3_1
Xhold350 instance_1.mem\[2\]\[31\] VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__dlygate4sd3_1
Xhold394 instance_1.mem\[2\]\[34\] VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__dlygate4sd3_1
Xhold383 instance_1.mem\[2\]\[38\] VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__dlygate4sd3_1
Xhold372 instance_1.mem\[2\]\[25\] VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_39_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3010_ instance_1.mem\[3\]\[34\] _1389_ _1372_ instance_1.mem\[2\]\[34\] VGND VGND
+ VPWR VPWR _1392_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_48_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3912_ net588 net58 _1903_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3843_ _1871_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_62_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3774_ _1833_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2725_ _1107_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_8_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
X_2656_ instance_0.mem\[0\]\[19\] instance_0.mem\[1\]\[19\] instance_0.mem\[2\]\[19\]
+ instance_0.mem\[3\]\[19\] _1069_ _1071_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__mux4_1
X_2587_ _1033_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__buf_4
XFILLER_0_10_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4326_ clknet_leaf_21_clk net258 VGND VGND VPWR VPWR instance_0.rdata\[48\] sky130_fd_sc_hd__dfxtp_1
X_4257_ clknet_leaf_8_clk _0093_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_3208_ _0969_ net591 _1519_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__mux2_1
X_4188_ clknet_leaf_3_clk _0024_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_3139_ instance_1.mem\[1\]\[70\] _1448_ _1094_ instance_1.mem\[3\]\[70\] VGND VGND
+ VPWR VPWR _1485_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_53_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold180 _0185_ VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold191 instance_1.rdata\[20\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_83_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2510_ _0877_ net648 _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__mux2_1
X_3490_ _1678_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__clkbuf_1
X_2441_ _0971_ net843 _0961_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2372_ _0924_ net950 _0922_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__mux2_1
X_4111_ _2017_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__clkbuf_1
X_4042_ _1980_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_67_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4875_ clknet_leaf_33_clk _0711_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3826_ _1862_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__clkbuf_1
X_3757_ _1824_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2708_ instance_0.mem\[2\]\[32\] _1100_ _1050_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__a21o_1
X_3688_ _1786_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__clkbuf_1
X_2639_ _1112_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
X_4309_ clknet_leaf_24_clk net374 VGND VGND VPWR VPWR instance_0.rdata\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2990_ _1377_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_72_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4660_ clknet_leaf_34_clk _0496_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_3611_ _1744_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4591_ clknet_leaf_32_clk _0427_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_3542_ _1706_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3473_ _1669_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__clkbuf_1
X_2424_ net20 VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2355_ net26 VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_19_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2286_ net53 VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__clkbuf_2
X_4025_ _1971_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_35_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4858_ clknet_leaf_50_clk _0694_ VGND VGND VPWR VPWR instance_1.mem\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3809_ _1838_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__buf_2
X_4789_ clknet_leaf_51_clk _0625_ VGND VGND VPWR VPWR instance_1.mem\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_77_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2140_ _0764_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__clkbuf_4
X_2071_ _0734_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_49_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2973_ instance_1.mem\[0\]\[24\] _1339_ _1316_ instance_1.mem\[2\]\[24\] _1364_ VGND
+ VGND VPWR VPWR _1365_ sky130_fd_sc_hd__a221o_1
X_4712_ clknet_leaf_52_clk _0548_ VGND VGND VPWR VPWR instance_0.mem\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4643_ clknet_leaf_37_clk _0479_ VGND VGND VPWR VPWR instance_1.mem\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4574_ clknet_leaf_38_clk _0410_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold702 instance_1.mem\[0\]\[16\] VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlygate4sd3_1
X_3525_ _1697_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__clkbuf_1
Xhold713 instance_0.mem\[2\]\[13\] VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__dlygate4sd3_1
Xhold724 instance_0.mem\[2\]\[54\] VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__dlygate4sd3_1
Xhold746 instance_0.mem\[0\]\[23\] VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__dlygate4sd3_1
Xhold735 instance_1.mem\[2\]\[40\] VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__dlygate4sd3_1
Xhold768 instance_0.mem\[1\]\[36\] VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__dlygate4sd3_1
Xhold779 instance_0.mem\[2\]\[71\] VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__dlygate4sd3_1
Xhold757 instance_0.mem\[3\]\[37\] VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__dlygate4sd3_1
X_3456_ _1659_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__clkbuf_1
X_3387_ _1622_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2407_ _0947_ net741 _0948_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2338_ net71 VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__clkbuf_2
X_2269_ net408 _0851_ _0852_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__mux2_1
X_4008_ _0807_ net937 _1961_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold40 _0226_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 instance_0.rdata\[42\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 _0195_ VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 instance_0.rdata\[66\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_85_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold84 _0182_ VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 instance_0.rdata\[32\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_20_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 _1276_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3310_ _1580_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4290_ clknet_leaf_39_clk net158 VGND VGND VPWR VPWR instance_0.rdata\[12\] sky130_fd_sc_hd__dfxtp_1
X_3241_ _1542_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
X_3172_ _1504_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
X_2123_ _0762_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2054_ _0725_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__buf_1
XFILLER_0_76_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2956_ _1069_ _1070_ instance_1.mem\[3\]\[20\] VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__and3_1
X_2887_ instance_1.mem\[0\]\[3\] _1276_ _1262_ instance_1.mem\[3\]\[3\] VGND VGND
+ VPWR VPWR _1300_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4626_ clknet_leaf_60_clk _0462_ VGND VGND VPWR VPWR instance_1.mem\[3\]\[60\] sky130_fd_sc_hd__dfxtp_1
Xhold510 instance_0.mem\[2\]\[60\] VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__dlygate4sd3_1
Xhold543 instance_1.mem\[2\]\[30\] VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlygate4sd3_1
Xhold532 instance_1.mem\[1\]\[71\] VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__dlygate4sd3_1
Xhold521 instance_1.mem\[2\]\[3\] VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__dlygate4sd3_1
X_4557_ clknet_leaf_58_clk _0393_ VGND VGND VPWR VPWR instance_0.mem\[2\]\[63\] sky130_fd_sc_hd__dfxtp_1
Xhold554 instance_0.mem\[3\]\[22\] VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__dlygate4sd3_1
Xhold576 instance_0.mem\[2\]\[34\] VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dlygate4sd3_1
Xhold565 instance_0.mem\[3\]\[7\] VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dlygate4sd3_1
X_4488_ clknet_leaf_54_clk _0324_ VGND VGND VPWR VPWR instance_0.mem\[1\]\[66\] sky130_fd_sc_hd__dfxtp_1
Xhold587 instance_0.mem\[3\]\[13\] VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlygate4sd3_1
X_3508_ _1688_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__clkbuf_1
Xhold598 instance_0.mem\[0\]\[67\] VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dlygate4sd3_1
X_3439_ _1650_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_43_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput85 net85 VGND VGND VPWR VPWR rdata[17] sky130_fd_sc_hd__buf_2
Xoutput96 net96 VGND VGND VPWR VPWR rdata[27] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3790_ net869 net37 _1839_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2810_ _1066_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__buf_4
X_2741_ _1059_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4411_ clknet_leaf_1_clk net312 VGND VGND VPWR VPWR instance_1.rdata\[61\] sky130_fd_sc_hd__dfxtp_1
X_2672_ instance_0.mem\[0\]\[23\] _1060_ _1113_ instance_0.mem\[3\]\[23\] VGND VGND
+ VPWR VPWR _1137_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4342_ clknet_leaf_4_clk net208 VGND VGND VPWR VPWR instance_0.rdata\[64\] sky130_fd_sc_hd__dfxtp_1
X_4273_ clknet_leaf_55_clk _0109_ VGND VGND VPWR VPWR instance_0.mem\[0\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_3224_ _1532_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
.ends
